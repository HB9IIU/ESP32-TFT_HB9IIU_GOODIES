#ifndef _NOTOSANS_MEDIUMITALIC72PT7B_H_
#define _NOTOSANS_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0xF8, 0x3C, 0x01, 0xFE, 0x0F, 0x00, 0xC0, 0x1F, 0xC1,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x03, 0xF8, 0x3E, 0x00,
  0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x1F, 0xF3,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x3F, 0xF0, 0x00,
  0x01, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x7F,
  0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x3E, 0x0F, 0xF0, 0x80,
  0x03, 0xE0, 0xFE, 0x0E, 0x00, 0x7C, 0x1F, 0xE0, 0xFE, 0x07, 0xC7, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x04, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x0F, 0xF8,
  0x3F, 0x00, 0xFE, 0x1F, 0x87, 0xFF, 0xC7, 0xF0, 0x1F, 0x87, 0xF1, 0xFF,
  0xFC, 0xFE, 0x07, 0xF0, 0xFC, 0x7F, 0xFF, 0x8F, 0xC1, 0xFC, 0x3F, 0x1F,
  0xFF, 0xF9, 0xFE, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xFF, 0xE3, 0xF8,
  0xFE, 0x07, 0xE3, 0xFF, 0xF8, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0xFE, 0x1F,
  0x87, 0xF0, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87,
  0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x38,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01,
  0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xF9, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC1, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x30, 0x03, 0xFC,
  0x00, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0x8F, 0xF7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0xFF, 0xF3, 0xFC, 0x7F, 0xE3, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x07,
  0xF8, 0x1C, 0x07, 0xF8, 0x10, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x20, 0x00,
  0x00, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xE0, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFF, 0x00,
  0x3F, 0xCF, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x9F,
  0xE0, 0x07, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF8, 0x7F, 0xF9, 0xF8, 0x01, 0xFF, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x7E, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0xFC,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x1F, 0xFC, 0x1F, 0xE0, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0xFE,
  0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x10,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x3F,
  0xFF, 0xE3, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xFF, 0xF1, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x7F,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE0, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x81,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0xE0, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC7, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xFF,
  0x87, 0xF0, 0x07, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xF9, 0xF8, 0x07,
  0xFF, 0xFF, 0xDF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F,
  0x00, 0x7F, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF,
  0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0x8F, 0xFF, 0xE0, 0x03, 0xFC, 0xFF,
  0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xFE,
  0x00, 0xFC, 0xFF, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xFE, 0x00, 0x7E, 0x0F,
  0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3C, 0x03, 0xFE, 0x00, 0x08, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x7F, 0xE0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFF,
  0xC7, 0xF8, 0x00, 0x7F, 0xFF, 0xE7, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xF0,
  0x01, 0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0xFC,
  0x00, 0x3F, 0xFF, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xF9, 0xFC, 0x00, 0x1F,
  0xFF, 0xE1, 0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xFF, 0x01,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xFC, 0x7F, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xE8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x3F, 0xF0, 0x01, 0xE0, 0x3F,
  0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x41, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xF1, 0xFC,
  0x01, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xEF, 0xE0, 0x07, 0xFF,
  0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xC7, 0xF0,
  0x00, 0x7F, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x18,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x80, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF,
  0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x83, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0xFF, 0xBF, 0x83, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x00,
  0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xC3, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xFF,
  0xE0, 0x1F, 0xCF, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0x00,
  0x3F, 0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x7F,
  0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xF9, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x7F, 0x00, 0x7F, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F,
  0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0x00, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x64,
  0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC1, 0xFF, 0x80, 0x3F, 0x0F, 0xFE, 0x01,
  0xFC, 0x7F, 0xF8, 0x07, 0xF3, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x00,
  0x10, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xC0, 0x00, 0x3F, 0xC1, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFB, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xF8,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xF7, 0xC0, 0x07,
  0xF8, 0x7F, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF7, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xE7,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7E, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xF0,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x4F, 0xFF, 0xE0, 0x00,
  0x37, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFB, 0x00, 0x03,
  0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xFC, 0x20, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 20, 52, 19, 1, -51 },
  { 131, 23, 18, 30, 8, -51 },
  { 183, 45, 51, 47, 2, -51 },
  { 470, 36, 59, 40, 2, -55 },
  { 736, 51, 53, 59, 5, -52 },
  { 1074, 46, 53, 49, 2, -52 },
  { 1379, 10, 18, 17, 8, -51 },
  { 1402, 24, 62, 22, 3, -51 },
  { 1588, 24, 63, 22, -5, -52 },
  { 1777, 34, 34, 40, 7, -55 },
  { 1922, 34, 35, 41, 5, -43 },
  { 2071, 15, 17, 19, -3, -8 },
  { 2103, 19, 7, 23, 2, -23 },
  { 2120, 10, 10, 19, 1, -9 },
  { 2133, 36, 52, 27, -3, -52 },
  { 2367, 35, 53, 40, 4, -52 },
  { 2599, 24, 51, 40, 9, -51 },
  { 2752, 38, 52, 40, 0, -52 },
  { 2999, 37, 53, 40, 1, -52 },
  { 3245, 38, 51, 40, 0, -51 },
  { 3488, 37, 52, 40, 2, -51 },
  { 3729, 36, 53, 40, 4, -52 },
  { 3968, 36, 51, 40, 5, -51 },
  { 4198, 36, 53, 40, 3, -52 },
  { 4437, 35, 53, 40, 3, -52 },
  { 4669, 16, 41, 19, 1, -40 },
  { 4751, 21, 49, 19, -4, -40 },
  { 4880, 34, 36, 41, 5, -44 },
  { 5033, 34, 20, 41, 5, -35 },
  { 5118, 34, 36, 41, 5, -44 },
  { 5271, 27, 53, 32, 6, -52 },
  { 5450, 56, 58, 61, 4, -51 },
  { 5856, 42, 51, 42, -4, -51 },
  { 6124, 40, 51, 44, 3, -51 },
  { 6379, 41, 53, 43, 5, -52 },
  { 6651, 43, 51, 48, 3, -51 },
  { 6926, 37, 51, 38, 3, -51 },
  { 7162, 37, 51, 36, 3, -51 },
  { 7398, 43, 53, 49, 5, -52 },
  { 7683, 47, 51, 49, 3, -51 },
  { 7983, 31, 51, 25, -2, -51 },
  { 8181, 33, 65, 21, -11, -51 },
  { 8450, 45, 51, 42, 3, -51 },
  { 8737, 28, 51, 35, 3, -51 },
  { 8916, 59, 51, 61, 3, -51 },
  { 9293, 49, 51, 52, 3, -51 },
  { 9606, 45, 53, 52, 5, -52 },
  { 9905, 39, 51, 42, 3, -51 },
  { 10154, 45, 64, 52, 5, -52 },
  { 10514, 38, 51, 42, 3, -51 },
  { 10757, 37, 53, 37, 1, -52 },
  { 11003, 37, 51, 37, 6, -51 },
  { 11239, 45, 52, 49, 5, -51 },
  { 11532, 40, 51, 41, 7, -51 },
  { 11787, 62, 51, 62, 7, -51 },
  { 12183, 50, 51, 40, -4, -51 },
  { 12502, 37, 51, 38, 7, -51 },
  { 12738, 43, 51, 38, -1, -51 },
  { 13013, 28, 62, 22, -1, -51 },
  { 13230, 14, 52, 27, 8, -52 },
  { 13321, 28, 62, 22, -5, -51 },
  { 13538, 36, 33, 41, 2, -52 },
  { 13687, 30, 5, 29, -7, 6 },
  { 13706, 12, 11, 21, 11, -55 },
  { 13723, 37, 41, 41, 3, -40 },
  { 13913, 37, 56, 42, 2, -55 },
  { 14172, 31, 41, 33, 3, -40 },
  { 14331, 40, 56, 42, 3, -55 },
  { 14611, 32, 41, 37, 3, -40 },
  { 14775, 41, 72, 24, -8, -55 },
  { 15144, 38, 57, 42, 2, -40 },
  { 15415, 36, 55, 42, 2, -55 },
  { 15663, 19, 54, 19, 2, -54 },
  { 15792, 30, 71, 19, -9, -54 },
  { 16059, 38, 55, 37, 2, -55 },
  { 16321, 19, 55, 19, 2, -55 },
  { 16452, 58, 40, 64, 2, -40 },
  { 16742, 36, 40, 42, 2, -40 },
  { 16922, 35, 40, 41, 3, -39 },
  { 17097, 41, 56, 42, -2, -39 },
  { 17384, 37, 57, 42, 3, -40 },
  { 17648, 30, 40, 29, 2, -40 },
  { 17798, 31, 41, 32, 0, -40 },
  { 17957, 25, 48, 26, 3, -47 },
  { 18107, 36, 40, 42, 4, -39 },
  { 18287, 34, 39, 35, 4, -39 },
  { 18453, 52, 39, 53, 4, -39 },
  { 18707, 41, 39, 36, -3, -39 },
  { 18907, 44, 56, 35, -6, -39 },
  { 19215, 33, 39, 33, -1, -39 },
  { 19376, 28, 62, 25, 1, -51 },
  { 19593, 6, 72, 40, 18, -55 },
  { 19647, 28, 62, 25, -3, -51 },
  { 19864, 34, 10, 41, 5, -30 },
};

const GFXfont NotoSans_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_MEDIUMITALIC72PT7B_H_
