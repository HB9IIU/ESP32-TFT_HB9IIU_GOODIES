#ifndef _NOTOSANS_MEDIUMITALIC47PT7B_H_
#define _NOTOSANS_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x3E, 0x3E,
  0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C,
  0x3C, 0x70, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xF7, 0x3E, 0x07, 0xC7,
  0x04, 0x07, 0xC7, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0x8E,
  0x00, 0x0F, 0xCE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3D, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x38, 0xF8, 0x00, 0x70, 0xF8, 0xE0, 0x71, 0xF8, 0xFC, 0x77,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xFE, 0x00, 0x1F,
  0x03, 0xFF, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x80, 0xF8, 0x3C, 0x07,
  0x80, 0x78, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x07, 0xC0, 0x1E, 0x07, 0x83,
  0xC0, 0x0F, 0x03, 0xC3, 0xC0, 0x0F, 0x83, 0xE3, 0xC0, 0x07, 0x81, 0xE1,
  0xE0, 0x83, 0xC0, 0xF1, 0xE3, 0xF9, 0xF0, 0xF1, 0xE7, 0xFE, 0x78, 0x79,
  0xF7, 0xFF, 0xBF, 0xF8, 0xF3, 0xE3, 0xDF, 0xFC, 0xF3, 0xE1, 0xE7, 0xF8,
  0xF1, 0xE0, 0xF0, 0xF8, 0xF9, 0xF0, 0x78, 0x00, 0x78, 0xF0, 0x3C, 0x00,
  0x78, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x7C, 0x1E, 0x07, 0x80,
  0x3C, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x07, 0x81, 0xE0,
  0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x78, 0xF8,
  0x1E, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0xFF, 0xF8, 0x07,
  0xC7, 0xE3, 0xE0, 0x3E, 0x3F, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x87, 0xC7,
  0xC0, 0x3F, 0x3E, 0x1F, 0x00, 0x7C, 0xF8, 0x7C, 0x01, 0xFF, 0xC3, 0xF0,
  0x03, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0xFF, 0x01, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFB,
  0xF0, 0x1F, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3E, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x3F, 0x1E, 0x00, 0xFF, 0x70, 0x01, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFB, 0xC0, 0x07, 0xCF,
  0x00, 0x3F, 0x1E, 0x01, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x06, 0x07, 0xC0,
  0x08, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00,
  0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE6, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF1, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x7F,
  0xBE, 0x7C, 0x7C, 0xF0, 0xF8, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0x00, 0xFC, 0x02, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xE0, 0xFE, 0x03, 0x80, 0x3F, 0x01, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x80, 0x03, 0xF0, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xC0,
  0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x78,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x80, 0x03, 0xF0, 0xF0, 0x07, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xE0, 0x40, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x8F, 0xF0, 0x1F, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7B, 0xFF,
  0xF1, 0xFE, 0x07, 0xE3, 0xF8, 0x07, 0xC7, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07,
  0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x03,
  0xF1, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x1F, 0x87, 0xE0, 0x3E, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0x7E,
  0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3F, 0x01, 0xFC, 0x3F, 0x0F, 0xF8, 0x7F, 0xFD, 0xF0, 0x7F, 0xFB, 0xE0,
  0x7F, 0xCF, 0x80, 0x1C, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x10, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E,
  0x06, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0x8C, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x1F, 0xF8, 0x3C, 0x3C, 0x03, 0xFF, 0xE0, 0xF1, 0xE0, 0x7F, 0xFE,
  0x07, 0x9E, 0x07, 0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0x81, 0xEF, 0x03,
  0xE0, 0x3C, 0x0F, 0x78, 0x3E, 0x03, 0xC0, 0x7B, 0xC1, 0xE0, 0x1E, 0x03,
  0xDE, 0x0F, 0x00, 0xF0, 0x1E, 0xF0, 0xF8, 0x07, 0x81, 0xEF, 0x07, 0x80,
  0x78, 0x0F, 0x78, 0x3C, 0x03, 0xC0, 0x7B, 0xC1, 0xE0, 0x3E, 0x07, 0x9E,
  0x0F, 0x01, 0xF0, 0x3C, 0xF8, 0x7C, 0x1F, 0x83, 0xC3, 0xC1, 0xF3, 0xDE,
  0x7E, 0x1E, 0x0F, 0xFC, 0xFF, 0xE0, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFE, 0x1F, 0x00, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFC, 0x07, 0xF0, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x70, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF0, 0x7C, 0x01, 0xFE, 0x07,
  0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xE0, 0x3F,
  0xC0, 0x0E, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xEF, 0xC0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xCF,
  0xC0, 0x1F, 0xFC, 0xFC, 0x02, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xFC,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x02, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xFC,
  0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x1E, 0xF8,
  0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x07, 0xDF, 0x03, 0xE7, 0x80, 0x1E, 0x7C,
  0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x3E, 0x78, 0x03, 0xC7, 0xC0, 0xF1, 0xE0,
  0x1F, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x0F, 0x81, 0xF1, 0xF0, 0x7C, 0x3C, 0x07, 0x83, 0xC1,
  0xE1, 0xF0, 0x1E, 0x0F, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x3C, 0x1F, 0x03,
  0xE0, 0xF1, 0xE0, 0x7C, 0x0F, 0x83, 0xC7, 0x81, 0xE0, 0x3C, 0x0F, 0x3C,
  0x0F, 0x81, 0xF0, 0x3D, 0xF0, 0x3E, 0x07, 0xC0, 0xF7, 0x80, 0xF8, 0x1F,
  0x03, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0xC0,
  0x7C, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0x1F, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x3E, 0x07, 0xFE, 0x00,
  0x3E, 0x07, 0xFE, 0x00, 0x3E, 0x07, 0xBE, 0x00, 0x3C, 0x07, 0x9F, 0x00,
  0x7C, 0x07, 0x9F, 0x00, 0x7C, 0x0F, 0x9F, 0x00, 0x7C, 0x0F, 0x8F, 0x80,
  0x7C, 0x0F, 0x8F, 0x80, 0x78, 0x0F, 0x07, 0x80, 0xF8, 0x0F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xF0, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF1,
  0xF0, 0x3E, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0xF9, 0xE0, 0x3C, 0x00, 0xFB,
  0xE0, 0x7C, 0x00, 0xFB, 0xE0, 0x7C, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x7F,
  0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFE, 0x1F,
  0x01, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x01, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x7E,
  0x07, 0xE0, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xE0,
  0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x3C,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xFE, 0x00, 0xF8,
  0xF8, 0x03, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xF8, 0x07,
  0xBE, 0x03, 0xE0, 0xF8, 0x0F, 0x9E, 0x03, 0xE0, 0xF8, 0x0F, 0x1E, 0x03,
  0xE0, 0xF8, 0x1F, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x1E, 0x07, 0xC0, 0xF8,
  0x3E, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x1E,
  0x1F, 0x00, 0x78, 0x7C, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x1E, 0x1E, 0x00,
  0x78, 0xF8, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00, 0x79, 0xF0,
  0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0x87, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC1, 0xF0,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x0F,
  0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0xFC, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x0F, 0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xDF, 0x0F, 0xF3, 0xFE,
  0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xE0, 0x3F, 0xF1, 0xE0,
  0x0F, 0xE1, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE1, 0xE0,
  0x07, 0xC7, 0xF8, 0x07, 0xCF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xBC, 0x7E,
  0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7F, 0x01, 0xF8,
  0x7F, 0x83, 0xF8, 0x7B, 0xFF, 0xF0, 0x7B, 0xFF, 0xE0, 0xF9, 0xFF, 0xC0,
  0xF0, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xF1, 0xE0, 0xFC, 0x02, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x10, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xFC, 0x7C, 0x03,
  0xFF, 0x9F, 0x01, 0xFF, 0xF7, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7F,
  0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0x78, 0x03, 0xFF,
  0x9E, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F, 0x87, 0xE0, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xFC, 0xF9, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0xE0, 0xFF, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x20, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x7F, 0xF1, 0xE0, 0x7F, 0xFD, 0xF0,
  0x7F, 0x9F, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x7F, 0xC0, 0xFF, 0xFB, 0xE0, 0x3F,
  0xF9, 0xE0, 0x1F, 0xF9, 0xF0, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x81,
  0x00, 0x0F, 0x80, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x07, 0xC7, 0xFC, 0x07, 0xCF, 0xFE, 0x07, 0xDF,
  0xFE, 0x07, 0xBE, 0x7F, 0x07, 0xF8, 0x3F, 0x0F, 0xF0, 0x1F, 0x0F, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x20, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE3,
  0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x1E,
  0x1F, 0xE0, 0x7F, 0xC0, 0x78, 0xFF, 0xC3, 0xFF, 0x81, 0xE7, 0xFF, 0x9F,
  0xFE, 0x07, 0xBC, 0x7E, 0xF9, 0xFC, 0x1F, 0xC0, 0xFF, 0x81, 0xF0, 0xFE,
  0x03, 0xFC, 0x07, 0xC3, 0xF8, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x03,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC7, 0xFC, 0x07, 0x8F, 0xFE, 0x07, 0x9F, 0xFE, 0x07, 0xBE,
  0x7F, 0x0F, 0xF8, 0x3F, 0x0F, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0x1F, 0x87, 0xE0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0,
  0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x7F, 0x80, 0x1E, 0x3F, 0xF0, 0x07, 0x9F, 0xFE, 0x01, 0xEF, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x3F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF,
  0xE0, 0x1E, 0x7F, 0xF0, 0x0F, 0x87, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0x8F, 0x03, 0xFF, 0xCF, 0x07, 0xFF, 0xDF, 0x0F, 0xF3, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7C,
  0x0F, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F, 0xF3, 0xE0, 0x0F,
  0xE3, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x7C, 0x7E, 0x07, 0x8F, 0xE0, 0x79, 0xFE, 0x07, 0xBF, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xC1, 0xE1, 0xF8, 0x02, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x80, 0x0F, 0x8C, 0x01, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF0, 0x0F, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0x83, 0xFE, 0x1F,
  0xFF, 0x7C, 0x3F, 0xFC, 0xF8, 0x3F, 0xF1, 0xE0, 0x3F, 0xC3, 0xC0, 0xF8,
  0x00, 0x7E, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xFC, 0x03, 0xC1, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x01, 0xFB,
  0xE0, 0x3F, 0x80, 0x7C, 0xF8, 0x0E, 0xE0, 0x1F, 0x3E, 0x07, 0xB8, 0x0F,
  0x8F, 0x81, 0xEF, 0x03, 0xE3, 0xE0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0,
  0x7C, 0x3E, 0x1F, 0x3C, 0x3E, 0x0F, 0x87, 0x8F, 0x0F, 0x83, 0xE3, 0xE3,
  0xC7, 0xC0, 0xF8, 0xF0, 0xF1, 0xF0, 0x3E, 0x3C, 0x3C, 0x78, 0x0F, 0x9E,
  0x0F, 0x3E, 0x03, 0xE7, 0x83, 0xCF, 0x00, 0xFB, 0xC0, 0xF7, 0xC0, 0x3E,
  0xF0, 0x3D, 0xF0, 0x07, 0xF8, 0x0F, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xE8, 0x00,
  0x3E, 0x00,
};

const GFXglyph NotoSans_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 35, 13, 1, -34 },
  { 58, 15, 13, 19, 5, -34 },
  { 83, 30, 34, 30, 1, -34 },
  { 211, 24, 39, 26, 1, -36 },
  { 328, 33, 34, 38, 3, -34 },
  { 469, 30, 34, 32, 1, -34 },
  { 597, 7, 13, 11, 5, -34 },
  { 609, 16, 41, 14, 2, -34 },
  { 691, 16, 41, 14, -4, -34 },
  { 773, 22, 22, 26, 5, -36 },
  { 834, 22, 23, 27, 3, -28 },
  { 898, 10, 11, 12, -2, -5 },
  { 912, 12, 5, 15, 1, -15 },
  { 920, 6, 7, 12, 1, -6 },
  { 926, 24, 34, 18, -2, -34 },
  { 1028, 23, 34, 26, 2, -34 },
  { 1126, 15, 34, 26, 6, -34 },
  { 1190, 25, 34, 26, 0, -34 },
  { 1297, 24, 34, 26, 1, -34 },
  { 1399, 25, 34, 26, 0, -34 },
  { 1506, 24, 34, 26, 1, -34 },
  { 1608, 23, 34, 26, 3, -34 },
  { 1706, 24, 34, 26, 3, -34 },
  { 1808, 24, 34, 26, 2, -34 },
  { 1910, 23, 34, 26, 2, -34 },
  { 2008, 10, 27, 12, 1, -26 },
  { 2042, 13, 32, 12, -2, -26 },
  { 2094, 22, 24, 27, 3, -29 },
  { 2160, 22, 13, 27, 3, -23 },
  { 2196, 22, 24, 27, 3, -29 },
  { 2262, 18, 35, 21, 4, -34 },
  { 2341, 37, 38, 40, 2, -34 },
  { 2517, 28, 34, 27, -3, -34 },
  { 2636, 26, 34, 28, 2, -34 },
  { 2747, 27, 34, 28, 3, -34 },
  { 2862, 28, 34, 31, 2, -34 },
  { 2981, 24, 34, 25, 2, -34 },
  { 3083, 24, 34, 23, 2, -34 },
  { 3185, 28, 34, 32, 3, -34 },
  { 3304, 30, 34, 32, 2, -34 },
  { 3432, 20, 34, 16, -1, -34 },
  { 3517, 21, 43, 14, -7, -34 },
  { 3630, 29, 34, 27, 2, -34 },
  { 3754, 18, 34, 23, 2, -34 },
  { 3831, 38, 34, 40, 2, -34 },
  { 3993, 32, 34, 34, 2, -34 },
  { 4129, 30, 34, 34, 3, -34 },
  { 4257, 25, 34, 27, 2, -34 },
  { 4364, 30, 42, 34, 3, -34 },
  { 4522, 25, 34, 28, 2, -34 },
  { 4629, 24, 34, 24, 1, -34 },
  { 4731, 24, 34, 24, 4, -34 },
  { 4833, 29, 34, 32, 4, -34 },
  { 4957, 27, 34, 26, 4, -34 },
  { 5072, 40, 34, 41, 5, -34 },
  { 5242, 33, 34, 26, -3, -34 },
  { 5383, 25, 34, 25, 4, -34 },
  { 5490, 28, 34, 25, -1, -34 },
  { 5609, 19, 41, 14, -1, -34 },
  { 5707, 10, 34, 18, 5, -34 },
  { 5750, 18, 41, 14, -3, -34 },
  { 5843, 24, 22, 27, 1, -34 },
  { 5909, 19, 3, 19, -4, 4 },
  { 5917, 8, 8, 14, 7, -36 },
  { 5925, 24, 26, 27, 2, -26 },
  { 6003, 24, 36, 27, 1, -36 },
  { 6111, 20, 26, 22, 2, -26 },
  { 6176, 26, 36, 27, 2, -36 },
  { 6293, 21, 26, 24, 2, -26 },
  { 6362, 26, 47, 16, -5, -36 },
  { 6515, 25, 37, 27, 1, -26 },
  { 6631, 24, 36, 28, 1, -36 },
  { 6739, 12, 35, 13, 1, -35 },
  { 6792, 19, 46, 13, -6, -35 },
  { 6902, 25, 36, 24, 1, -36 },
  { 7015, 13, 36, 13, 1, -36 },
  { 7074, 38, 26, 42, 1, -26 },
  { 7198, 24, 26, 28, 1, -26 },
  { 7276, 23, 26, 27, 2, -26 },
  { 7351, 26, 37, 27, -1, -26 },
  { 7472, 24, 37, 27, 2, -26 },
  { 7583, 20, 26, 19, 1, -26 },
  { 7648, 20, 26, 21, 0, -26 },
  { 7713, 16, 31, 17, 2, -31 },
  { 7775, 23, 25, 28, 3, -25 },
  { 7847, 23, 25, 23, 2, -25 },
  { 7919, 34, 25, 35, 3, -25 },
  { 8026, 27, 25, 23, -2, -25 },
  { 8111, 29, 36, 23, -4, -25 },
  { 8242, 22, 25, 21, -1, -25 },
  { 8311, 19, 41, 17, 0, -34 },
  { 8409, 4, 47, 26, 12, -36 },
  { 8433, 18, 41, 17, -2, -34 },
  { 8526, 22, 7, 27, 3, -20 },
};

const GFXfont NotoSans_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_MEDIUMITALIC47PT7B_H_
