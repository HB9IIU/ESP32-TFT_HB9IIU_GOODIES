#ifndef _NOTOSANS_MEDIUMITALIC8PT7B_H_
#define _NOTOSANS_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0x5E, 0xAF, 0xB0, 0x27, 0x63, 0x3E, 0xCE,
  0xBB, 0x75, 0xCC, 0x32, 0x8C, 0xD9, 0xF4, 0xC0, 0x29, 0x49, 0x30, 0x24,
  0x92, 0x70, 0x4F, 0xC2, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88,
  0x35, 0x59, 0x96, 0x39, 0x24, 0x80, 0x71, 0x12, 0x4F, 0x71, 0x17, 0x1E,
  0x13, 0x59, 0xF2, 0x34, 0x61, 0x1E, 0x34, 0x65, 0x96, 0xF2, 0x24, 0x88,
  0x35, 0x57, 0x97, 0x35, 0x57, 0x1E, 0x42, 0x42, 0x80, 0x3B, 0x10, 0xFC,
  0x89, 0xC0, 0xC5, 0x41, 0x00, 0x38, 0x89, 0xED, 0x5B, 0xC8, 0x0E, 0x00,
  0x33, 0x57, 0x99, 0x72, 0x54, 0xE5, 0x78, 0x78, 0x88, 0x8E, 0x72, 0x52,
  0x94, 0xF8, 0x74, 0x47, 0x4E, 0x74, 0x47, 0x48, 0x78, 0x8B, 0x9E, 0x45,
  0x24, 0x9E, 0x4A, 0x40, 0x69, 0x25, 0x80, 0x24, 0x92, 0x94, 0x4A, 0x98,
  0xC5, 0x48, 0x49, 0x25, 0xC0, 0x66, 0xCD, 0xB3, 0x6B, 0x52, 0x80, 0x65,
  0x96, 0x96, 0x9A, 0x60, 0x74, 0xA3, 0x29, 0x70, 0x72, 0x52, 0xE4, 0x40,
  0x74, 0xA3, 0x29, 0x70, 0xC0, 0x72, 0x54, 0xC5, 0x48, 0x34, 0x42, 0x1E,
  0xF4, 0x44, 0x88, 0x8C, 0xA5, 0x29, 0x70, 0x99, 0xAA, 0xC8, 0x93, 0x6A,
  0xD6, 0xCD, 0x92, 0x00, 0x4A, 0x88, 0xC6, 0x48, 0x9A, 0xC4, 0x88, 0x78,
  0x88, 0x84, 0x78, 0x69, 0x29, 0x30, 0xFC, 0x32, 0x22, 0x22, 0xC0, 0x26,
  0x59, 0xF0, 0xC0, 0x79, 0x97, 0x44, 0x75, 0x9E, 0x78, 0x86, 0x09, 0x55,
  0x29, 0x38, 0x7F, 0x86, 0x19, 0x1C, 0x42, 0x21, 0x18, 0x79, 0x97, 0x1E,
  0x44, 0x75, 0x99, 0x45, 0xA0, 0x20, 0x94, 0x96, 0x44, 0x56, 0xAB, 0x55,
  0xA0, 0x7E, 0xA6, 0x54, 0xA0, 0x75, 0x99, 0x79, 0x96, 0x75, 0x9E, 0x88,
  0x79, 0x97, 0x12, 0x74, 0x88, 0x68, 0xF0, 0x5D, 0x44, 0x55, 0x97, 0x9A,
  0x64, 0x96, 0xDD, 0x94, 0x56, 0x6A, 0x49, 0x8C, 0x42, 0x60, 0x72, 0x4E,
  0x29, 0x64, 0x90, 0xFF, 0x49, 0x34, 0xA0, 0xE0,
};

const GFXglyph NotoSans_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 7, 1, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 4, 4, 4, 1, -6 },
  { 28, 3, 4, 5, 1, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 4, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 1, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 1, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 3, 4, 5, 1, -5 },
  { 71, 3, 2, 5, 1, -4 },
  { 72, 3, 4, 5, 1, -5 },
  { 74, 3, 6, 4, 1, -6 },
  { 77, 7, 7, 7, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 6, 6, 5, 0, -6 },
  { 112, 3, 6, 3, 0, -6 },
  { 115, 3, 8, 2, -1, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 3, 6, 4, 0, -6 },
  { 125, 7, 6, 7, 0, -6 },
  { 131, 6, 6, 6, 0, -6 },
  { 136, 5, 6, 6, 1, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 7, 6, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 1, -6 },
  { 159, 5, 6, 5, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 7, 6, 7, 1, -6 },
  { 172, 5, 6, 4, 0, -6 },
  { 176, 4, 6, 4, 1, -6 },
  { 179, 5, 6, 4, 0, -6 },
  { 183, 3, 7, 2, 0, -6 },
  { 186, 1, 6, 3, 1, -6 },
  { 187, 4, 7, 2, -1, -6 },
  { 191, 4, 4, 5, 0, -6 },
  { 193, 4, 1, 3, -1, 0 },
  { 194, 2, 1, 2, 1, -6 },
  { 195, 4, 4, 5, 0, -4 },
  { 197, 4, 6, 5, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 5, 6, 5, 0, -6 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 5, 8, 3, -1, -6 },
  { 213, 4, 6, 5, 0, -4 },
  { 216, 4, 6, 5, 0, -6 },
  { 219, 2, 6, 2, 0, -6 },
  { 221, 3, 8, 2, -1, -6 },
  { 224, 4, 6, 4, 0, -6 },
  { 227, 2, 6, 2, 0, -6 },
  { 229, 7, 4, 7, 0, -4 },
  { 233, 4, 4, 5, 0, -4 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 4, 6, 5, 0, -4 },
  { 240, 4, 6, 5, 0, -4 },
  { 243, 4, 4, 3, 0, -4 },
  { 245, 3, 4, 4, 0, -4 },
  { 247, 3, 5, 3, 0, -5 },
  { 249, 4, 4, 5, 0, -4 },
  { 251, 4, 4, 4, 0, -4 },
  { 253, 6, 4, 6, 0, -4 },
  { 256, 4, 4, 4, 0, -4 },
  { 258, 5, 6, 4, -1, -4 },
  { 262, 4, 4, 4, 0, -4 },
  { 264, 3, 7, 3, 0, -6 },
  { 267, 1, 8, 4, 2, -6 },
  { 268, 3, 7, 3, 0, -6 },
  { 271, 3, 1, 5, 1, -3 },
};

const GFXfont NotoSans_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_MEDIUMITALIC8PT7B_H_
