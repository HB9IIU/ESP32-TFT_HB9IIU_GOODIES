#ifndef _NOTOSANS_MEDIUMITALIC53PT7B_H_
#define _NOTOSANS_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x7E, 0x1F,
  0xBF, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0xF8, 0x1F, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFC, 0xF1, 0xE0, 0x7C, 0x38, 0x08, 0x3F, 0x0E,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3F,
  0x1C, 0x00, 0x0F, 0xE7, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0xFE, 0x00, 0x07, 0x1F, 0x80, 0x01,
  0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0E, 0x0F, 0x88,
  0x03, 0x87, 0xE3, 0x01, 0xE3, 0xF0, 0xF8, 0x7B, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x1E,
  0x03, 0xF0, 0xF0, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x3E,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x07,
  0x80, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x03, 0xC0,
  0x7C, 0x7C, 0x00, 0x1E, 0x03, 0xC3, 0xC3, 0xF8, 0xF0, 0x3E, 0x3E, 0x7F,
  0xE7, 0xC1, 0xE3, 0xE7, 0xFF, 0xBE, 0x1F, 0x3E, 0x7F, 0xFD, 0xFF, 0xF1,
  0xE3, 0xE1, 0xF7, 0xFF, 0x1F, 0x3E, 0x0F, 0x9F, 0xF1, 0xF1, 0xF0, 0x7C,
  0x7F, 0x1F, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x3E, 0x00,
  0x7C, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0,
  0xF8, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x01, 0xFF, 0xF0,
  0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xFC, 0x01, 0xF8, 0xFE, 0x3F,
  0x00, 0xF8, 0xFE, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE0, 0xFC, 0x7E, 0x01,
  0xF8, 0x7C, 0x7E, 0x00, 0xFE, 0x7E, 0x3F, 0x00, 0x3F, 0x7E, 0x1F, 0x00,
  0x0F, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0x03, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0x01,
  0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x00,
  0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0x00, 0x78, 0x01,
  0xE0, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0x7F, 0x9E, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF7,
  0xFC, 0x07, 0xF8, 0x02, 0x07, 0xDE, 0x00, 0x07, 0xCF, 0x00, 0x07, 0xC7,
  0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x70,
  0x1F, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x3E, 0x3F, 0x1F, 0x1E, 0x1F,
  0x84, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xE0, 0x03, 0xF0, 0x04,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xC0, 0x1F, 0xC0, 0x20, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC4, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x81, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x84, 0x00, 0x07, 0xE0,
  0xC0, 0x03, 0xFC, 0x1F, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xE1, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0xF8, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xBF, 0xE1, 0xFF, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xC3,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF8, 0x7F, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xE0, 0x3F,
  0xF9, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xF8, 0xFF, 0x1C, 0x01, 0xF8, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x40, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0x01, 0xE1, 0xF0,
  0x0F, 0xFF, 0xE0, 0xF9, 0xF0, 0x0F, 0xFF, 0xE0, 0x7C, 0xF0, 0x0F, 0xC1,
  0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0x7C, 0x07,
  0xBC, 0x0F, 0x80, 0x3C, 0x07, 0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0x03,
  0xC0, 0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x07,
  0x80, 0x7B, 0xC0, 0xF0, 0x07, 0xC0, 0x3D, 0xE0, 0x78, 0x03, 0xE0, 0x3E,
  0xF0, 0x3C, 0x03, 0xE0, 0x1E, 0x78, 0x1E, 0x01, 0xF0, 0x1F, 0x3C, 0x0F,
  0x01, 0xF8, 0x0F, 0x1E, 0x07, 0xC1, 0xFE, 0x0F, 0x8F, 0x83, 0xF1, 0xEF,
  0x9F, 0x87, 0xC0, 0xFF, 0xE7, 0xFF, 0x83, 0xE0, 0x7F, 0xE1, 0xFF, 0x80,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x01, 0xC0, 0x7F, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x00, 0xFF, 0xE7, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x10,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0x81, 0xFF, 0x00, 0x02, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0B, 0xF0, 0x01, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xCF,
  0xC0, 0x0F, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x3F, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0xC0,
  0x07, 0xC0, 0x7F, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0x9F, 0xC0, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x7B, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0x78, 0x00, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00,
  0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x00, 0xF9,
  0xF8, 0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0,
  0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0x80, 0x3E, 0x1F, 0x01, 0xF0,
  0xF0, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x81, 0xF0,
  0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x78, 0x0F, 0x80, 0xFC,
  0x0F, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE7, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xFE, 0x01, 0xF8,
  0x0F, 0x80, 0x7F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x7F, 0x80, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0x1F, 0x7E,
  0x00, 0x3F, 0x00, 0xFB, 0xF0, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x0F, 0x80,
  0x7C, 0x7E, 0x00, 0x7C, 0x03, 0xE3, 0xF0, 0x07, 0xE0, 0x1F, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0xFC, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x0F, 0xCF, 0x80, 0x7C, 0x00, 0x7E,
  0x7C, 0x03, 0xE0, 0x01, 0xF7, 0xE0, 0x1F, 0x00, 0x0F, 0xFE, 0x01, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x07,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x0F, 0xE0, 0x7E, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xF0, 0x07, 0x01, 0xFC, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x04, 0x00, 0x0F, 0xE0, 0xE0, 0x03, 0xFC, 0x1F, 0xC7,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xFF, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xE0,
  0x7C, 0x01, 0xF3, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0x07,
  0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0xF0, 0x1F, 0x80, 0x7C,
  0x07, 0xC3, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x0F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x03,
  0xE7, 0xE0, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xF0, 0x03, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0x9F,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x81,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x07, 0xFE, 0x1E, 0x01, 0xFF,
  0xF3, 0xE0, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0x03, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE, 0x07,
  0xE0, 0x3F, 0xE0, 0x7F, 0x0F, 0xBC, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFE,
  0x7C, 0x01, 0xFF, 0xC7, 0xC0, 0x0F, 0xF8, 0x7C, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xF0, 0x07, 0xCF, 0xFF, 0x00,
  0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xF0,
  0xFF, 0x07, 0xDF, 0xFF, 0xC0, 0xFB, 0xFF, 0xF0, 0x1E, 0x3F, 0xFC, 0x07,
  0xC1, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x01,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x10, 0x3F, 0xC1, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xE3, 0xE0, 0x07,
  0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0xBE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xC3, 0xEF,
  0x00, 0x3F, 0xFF, 0x7C, 0x00, 0xFF, 0xF9, 0xF0, 0x01, 0xFF, 0xC7, 0xC0,
  0x03, 0xFE, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0xFE, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x01, 0xFE, 0x7E, 0x1F, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x3F, 0x80, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8,
  0x20, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xFF, 0x87, 0x80, 0x3F, 0xFE, 0x7C,
  0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0xDF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0xFC, 0x03, 0xFC,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x87, 0xFE, 0x00, 0xFF, 0xFD, 0xF0, 0x07,
  0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x07, 0xE0, 0x0F,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xF8, 0x07, 0xCF, 0xFF, 0x80, 0xFB, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xE0, 0xFF, 0x80, 0xFC, 0x1F,
  0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0x9F, 0xFE, 0x0F, 0xFF, 0x01, 0xF7, 0xFF, 0xC7, 0xFF,
  0xE0, 0x3D, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xBC, 0x1F, 0xBC, 0x0F, 0xC1,
  0xFE, 0x01, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x9F,
  0xFF, 0x01, 0xF7, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xBC, 0x0F, 0xC1,
  0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F,
  0xC3, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC3, 0xFE, 0x00,
  0x3E, 0x7F, 0xF8, 0x01, 0xF7, 0xFF, 0xE0, 0x0F, 0x7F, 0xFF, 0x00, 0xFF,
  0xC1, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0,
  0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0x80, 0xFB,
  0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0x80, 0x3E, 0x3F, 0xF8, 0x03, 0xF0, 0xFF,
  0x00, 0x1F, 0x80, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x07, 0xFE, 0x1E, 0x01, 0xFF, 0xF1, 0xE0,
  0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x3F,
  0xE0, 0x7F, 0x0F, 0xFC, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFE, 0x7C, 0x01,
  0xFF, 0xCF, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x0F, 0x8F, 0xF0, 0x3E, 0x7F,
  0xC0, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0x8F, 0x81, 0xF8, 0x03, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x60, 0x03, 0xF0, 0xF0, 0x0F, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x02, 0x00,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFE, 0x1F, 0x7C,
  0x1F, 0xFF, 0xCF, 0x01, 0xFF, 0xF3, 0xE0, 0x1F, 0xFC, 0x7C, 0x01, 0xFE,
  0x0F, 0x80, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xE7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0,
  0x1F, 0x9F, 0x80, 0x7F, 0x80, 0x7E, 0x3F, 0x01, 0xFF, 0x00, 0xFC, 0x7E,
  0x03, 0xDE, 0x01, 0xF0, 0xFC, 0x0F, 0xBC, 0x07, 0xE1, 0xF8, 0x1E, 0x78,
  0x0F, 0x81, 0xF0, 0x7C, 0xF0, 0x3F, 0x03, 0xE0, 0xF9, 0xF0, 0x7C, 0x07,
  0xC1, 0xE3, 0xE1, 0xF8, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x1F, 0x0F, 0x0F,
  0x8F, 0xC0, 0x3E, 0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0x78, 0x3E, 0x3E, 0x00,
  0xF9, 0xF0, 0x7C, 0xFC, 0x01, 0xF3, 0xC0, 0xF9, 0xF0, 0x03, 0xEF, 0x81,
  0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x07, 0xDF, 0x00,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x5F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xB0,
  0x03, 0xFF, 0xC8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 17, 14, 22, 6, -38 },
  { 100, 34, 38, 34, 1, -38 },
  { 262, 26, 43, 29, 2, -40 },
  { 402, 37, 39, 43, 4, -38 },
  { 583, 33, 39, 36, 2, -38 },
  { 744, 7, 14, 12, 6, -38 },
  { 757, 18, 46, 16, 2, -38 },
  { 861, 18, 46, 16, -4, -38 },
  { 965, 25, 24, 29, 5, -40 },
  { 1040, 26, 26, 30, 3, -32 },
  { 1125, 11, 13, 14, -2, -6 },
  { 1143, 14, 5, 17, 1, -17 },
  { 1152, 7, 8, 14, 1, -7 },
  { 1159, 26, 38, 20, -2, -38 },
  { 1283, 25, 39, 29, 3, -38 },
  { 1405, 17, 38, 29, 7, -38 },
  { 1486, 28, 38, 29, 0, -38 },
  { 1619, 27, 39, 29, 1, -38 },
  { 1751, 28, 38, 29, 0, -38 },
  { 1884, 27, 39, 29, 2, -38 },
  { 2016, 26, 39, 29, 3, -38 },
  { 2143, 26, 38, 29, 4, -38 },
  { 2267, 27, 39, 29, 2, -38 },
  { 2399, 26, 39, 29, 2, -38 },
  { 2526, 12, 30, 14, 1, -29 },
  { 2571, 16, 36, 14, -3, -29 },
  { 2643, 26, 26, 30, 3, -32 },
  { 2728, 24, 15, 30, 4, -26 },
  { 2773, 26, 26, 30, 3, -32 },
  { 2858, 21, 39, 23, 4, -38 },
  { 2961, 41, 43, 45, 3, -38 },
  { 3182, 31, 38, 31, -3, -38 },
  { 3330, 30, 38, 32, 2, -38 },
  { 3473, 30, 39, 32, 4, -38 },
  { 3620, 32, 38, 36, 2, -38 },
  { 3772, 28, 38, 28, 2, -38 },
  { 3905, 28, 38, 26, 2, -38 },
  { 4038, 31, 39, 36, 4, -38 },
  { 4190, 35, 38, 36, 2, -38 },
  { 4357, 22, 38, 18, -1, -38 },
  { 4462, 24, 48, 15, -8, -38 },
  { 4606, 33, 38, 31, 2, -38 },
  { 4763, 21, 38, 26, 2, -38 },
  { 4863, 43, 38, 45, 2, -38 },
  { 5068, 37, 38, 38, 2, -38 },
  { 5244, 33, 39, 38, 4, -38 },
  { 5405, 29, 38, 31, 2, -38 },
  { 5543, 33, 47, 38, 4, -38 },
  { 5737, 29, 38, 31, 2, -38 },
  { 5875, 27, 39, 27, 1, -38 },
  { 6007, 26, 38, 27, 5, -38 },
  { 6131, 33, 39, 36, 4, -38 },
  { 6292, 30, 38, 30, 5, -38 },
  { 6435, 46, 38, 46, 5, -38 },
  { 6654, 37, 38, 29, -3, -38 },
  { 6830, 28, 38, 28, 5, -38 },
  { 6963, 32, 38, 28, -1, -38 },
  { 7115, 21, 46, 16, -1, -38 },
  { 7236, 10, 38, 20, 6, -38 },
  { 7284, 21, 46, 16, -4, -38 },
  { 7405, 26, 24, 30, 2, -38 },
  { 7483, 22, 3, 21, -5, 5 },
  { 7492, 9, 9, 15, 8, -41 },
  { 7503, 28, 30, 30, 2, -29 },
  { 7608, 27, 41, 31, 1, -40 },
  { 7747, 23, 30, 24, 2, -29 },
  { 7834, 30, 41, 31, 2, -40 },
  { 7988, 24, 30, 27, 2, -29 },
  { 8078, 30, 54, 18, -6, -41 },
  { 8281, 29, 42, 31, 1, -29 },
  { 8434, 27, 40, 31, 1, -40 },
  { 8569, 14, 39, 14, 1, -39 },
  { 8638, 22, 52, 14, -7, -39 },
  { 8781, 28, 40, 27, 1, -40 },
  { 8921, 14, 40, 14, 1, -40 },
  { 8991, 43, 29, 47, 1, -29 },
  { 9147, 27, 29, 31, 1, -29 },
  { 9245, 26, 29, 30, 2, -29 },
  { 9340, 29, 42, 31, -1, -29 },
  { 9493, 28, 42, 31, 2, -29 },
  { 9640, 22, 29, 21, 1, -29 },
  { 9720, 23, 30, 24, 0, -29 },
  { 9807, 18, 36, 19, 2, -35 },
  { 9888, 27, 30, 31, 3, -29 },
  { 9990, 25, 29, 25, 3, -29 },
  { 10081, 39, 29, 39, 3, -29 },
  { 10223, 30, 29, 26, -2, -29 },
  { 10332, 33, 42, 26, -5, -29 },
  { 10506, 25, 29, 24, -1, -29 },
  { 10597, 22, 46, 19, 0, -38 },
  { 10724, 5, 53, 29, 13, -40 },
  { 10758, 21, 46, 19, -2, -38 },
  { 10879, 26, 7, 30, 3, -22 },
};

const GFXfont NotoSans_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_MEDIUMITALIC53PT7B_H_
