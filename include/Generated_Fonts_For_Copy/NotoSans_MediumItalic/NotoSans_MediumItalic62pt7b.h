#ifndef _NOTOSANS_MEDIUMITALIC62PT7B_H_
#define _NOTOSANS_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x3F, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F,
  0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xEF, 0xF0, 0x1F, 0xE3, 0xC1, 0xC0, 0x3F, 0x87, 0x80,
  0x80, 0xFE, 0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00,
  0x3F, 0xCF, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7B, 0xFE, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x03,
  0xC3, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C,
  0x1F, 0x80, 0x00, 0x78, 0x7F, 0x08, 0x01, 0xF0, 0xFE, 0x1E, 0x03, 0xC3,
  0xF8, 0x3F, 0xC7, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x0F, 0x83, 0xF8, 0x7C, 0x07,
  0xC3, 0xF1, 0xFF, 0x8F, 0x81, 0xF8, 0xFC, 0x7F, 0xF9, 0xF0, 0x3E, 0x3F,
  0x1F, 0xFF, 0xBF, 0x0F, 0xC7, 0xC7, 0xFF, 0xF7, 0xFF, 0xF1, 0xF9, 0xFC,
  0x3F, 0x7F, 0xFC, 0x7E, 0x3F, 0x07, 0xEF, 0xFF, 0x1F, 0x8F, 0xC0, 0x7C,
  0xFF, 0xC3, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFF,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xF8,
  0x00, 0xFC, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xE1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x1F, 0x80, 0x0F, 0xF3, 0xF8, 0x7F, 0x00, 0x0F, 0xE7, 0xE0,
  0xFE, 0x00, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x7F,
  0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xFC, 0x3C, 0x00, 0x3F, 0xF9, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xDE, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xEF, 0xCF,
  0xFC, 0xFC, 0x7F, 0x0F, 0xC7, 0xE1, 0xFC, 0x38, 0x1F, 0xC1, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0x7F, 0x80, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x80, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x08, 0x00,
  0x01, 0xFC, 0x1C, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF1, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF,
  0xC0, 0x7E, 0x7F, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFC,
  0x3F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC4, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0,
  0x7F, 0xFE, 0x7F, 0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x30, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3E, 0x01,
  0xFE, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x0F, 0x80,
  0x1F, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x1F, 0x00,
  0xFF, 0x03, 0xF0, 0x1F, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x3E, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0xF8, 0x0F,
  0x80, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0xFC, 0x0F,
  0x80, 0x7F, 0x00, 0xF8, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0xFC, 0x0F,
  0xE1, 0xFF, 0x83, 0xF0, 0x7C, 0x07, 0xFF, 0xEF, 0xFF, 0xE0, 0x7C, 0x07,
  0xFF, 0xC7, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7E, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x60, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x0C,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x01,
  0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFE, 0x3F,
  0x80, 0x07, 0xFF, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0x80,
  0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x1F,
  0x80, 0xFE, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xBF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF7, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x03, 0xF0,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x80, 0x03, 0xFB, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0x80,
  0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x81,
  0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFF, 0x07, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0x01,
  0xFE, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x7F, 0xC0, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x00,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x87,
  0xE0, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x01,
  0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x3F, 0xF8,
  0x3E, 0x00, 0x7F, 0xFC, 0x3E, 0x01, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xFF,
  0x7E, 0x07, 0xFF, 0x7F, 0x7E, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x83, 0xFF,
  0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x8F,
  0x80, 0x1F, 0xFE, 0x1F, 0x80, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x1F, 0xF8, 0x01,
  0xFC, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xBF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xF7, 0xFF, 0xFF, 0x07,
  0xEF, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xF0, 0x1F, 0x0F, 0xFF, 0x80, 0x3E,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xE7, 0xE0, 0x7F, 0xC0, 0x10, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x20, 0x7F, 0xC0, 0x38, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xFF, 0x87, 0xE0, 0x03, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFE,
  0x7E, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xFF, 0xE0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0xF8, 0x00, 0xFF, 0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0x8F, 0x80,
  0x07, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x1F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x9F, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x07,
  0xFC, 0x01, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x40, 0x03, 0xFF, 0x83, 0xE0, 0x03, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xFE,
  0x7E, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xF7, 0xF7, 0xE0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0xFB, 0xF0, 0x07,
  0xFF, 0xFD, 0xF8, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0x80,
  0x07, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x03, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x30, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xFC, 0x01,
  0xFC, 0x7F, 0xFC, 0x03, 0xF3, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xDF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x04, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x0F,
  0xF9, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0x7F, 0x3F, 0xCF,
  0xE7, 0xFC, 0x1F, 0xBC, 0x07, 0xF7, 0xC0, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xE1, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0xF8, 0x01, 0xF8, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE, 0x01, 0xFB,
  0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0x03, 0xF7, 0xC0, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0x9F, 0xFF, 0xC0, 0x03,
  0xE7, 0xFF, 0xFC, 0x00, 0x7D, 0xFD, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFE, 0x00, 0x7E, 0x3F, 0xFF,
  0x80, 0x0F, 0xC7, 0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x01,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x3F, 0xF8, 0x3E,
  0x00, 0xFF, 0xFC, 0x3E, 0x01, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xFF, 0x7E,
  0x07, 0xFF, 0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x83, 0xEF, 0xC0,
  0x7F, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0x1F, 0x80,
  0x1F, 0xFE, 0x3F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0xC0, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x3F, 0xC0, 0xFC, 0x7F, 0xE0, 0x7E, 0x7F, 0xE0, 0x3F, 0x7F, 0xF0,
  0x1F, 0x7F, 0xF8, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0x07, 0xE0, 0x7F, 0x00, 0x38, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0x00,
  0x03, 0xF8, 0xF0, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x04, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x03, 0xEF, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0,
  0x7F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x8F, 0x80, 0x1F, 0xFE, 0x0F, 0x80,
  0x0F, 0xFC, 0x0F, 0x80, 0x00, 0xC0, 0x10, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xE0, 0x03, 0xF9, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xCF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xDF, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xE7,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x3F, 0x01, 0xF9, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0x8F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x7C, 0x0F,
  0xE0, 0x7E, 0x07, 0xC3, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x1F, 0x07, 0xF0,
  0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x07, 0xC3, 0xF8, 0x07,
  0xE1, 0xF8, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0x81, 0xF1, 0xFC, 0x01, 0xF8,
  0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x00, 0x3E, 0x7E,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x3E,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xD0, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 45, 17, 1, -44 },
  { 97, 20, 16, 25, 7, -44 },
  { 137, 38, 44, 40, 2, -44 },
  { 346, 31, 51, 34, 2, -47 },
  { 544, 43, 46, 51, 5, -45 },
  { 792, 39, 46, 42, 2, -45 },
  { 1017, 8, 16, 14, 7, -44 },
  { 1033, 22, 54, 19, 2, -44 },
  { 1182, 21, 55, 19, -5, -45 },
  { 1327, 29, 29, 34, 6, -47 },
  { 1433, 29, 30, 35, 4, -37 },
  { 1542, 13, 15, 16, -3, -7 },
  { 1567, 17, 5, 20, 1, -19 },
  { 1578, 9, 9, 16, 1, -8 },
  { 1589, 31, 44, 23, -3, -44 },
  { 1760, 30, 46, 34, 3, -45 },
  { 1933, 20, 44, 34, 8, -44 },
  { 2043, 33, 45, 34, 0, -45 },
  { 2229, 32, 46, 34, 1, -45 },
  { 2413, 33, 44, 34, 0, -44 },
  { 2595, 31, 45, 34, 2, -44 },
  { 2770, 30, 46, 34, 4, -45 },
  { 2943, 31, 44, 34, 4, -44 },
  { 3114, 32, 46, 34, 2, -45 },
  { 3298, 30, 46, 34, 3, -45 },
  { 3471, 14, 35, 16, 1, -34 },
  { 3533, 18, 42, 16, -3, -34 },
  { 3628, 29, 31, 35, 4, -38 },
  { 3741, 29, 17, 35, 4, -30 },
  { 3803, 29, 31, 35, 4, -38 },
  { 3916, 24, 46, 27, 5, -45 },
  { 4054, 48, 50, 53, 3, -44 },
  { 4354, 37, 44, 36, -4, -44 },
  { 4558, 35, 44, 38, 2, -44 },
  { 4751, 36, 46, 37, 4, -45 },
  { 4958, 38, 44, 42, 2, -44 },
  { 5167, 33, 44, 32, 2, -44 },
  { 5349, 33, 44, 31, 2, -44 },
  { 5531, 37, 46, 42, 4, -45 },
  { 5744, 41, 44, 43, 2, -44 },
  { 5970, 26, 44, 21, -1, -44 },
  { 6113, 29, 56, 18, -10, -44 },
  { 6316, 39, 44, 36, 2, -44 },
  { 6531, 25, 44, 30, 2, -44 },
  { 6669, 51, 44, 53, 2, -44 },
  { 6950, 43, 44, 45, 2, -44 },
  { 7187, 39, 46, 45, 4, -45 },
  { 7412, 34, 44, 36, 2, -44 },
  { 7599, 39, 56, 45, 4, -45 },
  { 7872, 34, 44, 36, 2, -44 },
  { 8059, 32, 46, 32, 1, -45 },
  { 8243, 32, 44, 32, 5, -44 },
  { 8419, 38, 45, 42, 5, -44 },
  { 8633, 35, 44, 35, 6, -44 },
  { 8826, 53, 44, 54, 6, -44 },
  { 9118, 42, 44, 34, -3, -44 },
  { 9349, 32, 44, 33, 6, -44 },
  { 9525, 37, 44, 33, -1, -44 },
  { 9729, 25, 54, 19, -1, -44 },
  { 9898, 12, 44, 23, 7, -44 },
  { 9964, 24, 54, 19, -4, -44 },
  { 10126, 31, 29, 35, 2, -45 },
  { 10239, 26, 4, 25, -6, 6 },
  { 10252, 11, 9, 18, 9, -47 },
  { 10265, 32, 35, 36, 3, -34 },
  { 10405, 31, 48, 36, 2, -47 },
  { 10591, 26, 35, 29, 3, -34 },
  { 10705, 34, 48, 36, 3, -47 },
  { 10909, 27, 35, 32, 3, -34 },
  { 11028, 35, 62, 21, -7, -47 },
  { 11300, 34, 49, 36, 1, -34 },
  { 11509, 31, 47, 36, 2, -47 },
  { 11692, 16, 46, 17, 2, -46 },
  { 11784, 26, 61, 17, -8, -46 },
  { 11983, 33, 47, 32, 1, -47 },
  { 12177, 17, 47, 17, 1, -47 },
  { 12277, 49, 34, 55, 2, -34 },
  { 12486, 32, 34, 36, 1, -34 },
  { 12622, 29, 35, 35, 3, -34 },
  { 12749, 35, 49, 36, -2, -34 },
  { 12964, 32, 49, 36, 3, -34 },
  { 13160, 25, 34, 25, 2, -34 },
  { 13267, 26, 35, 28, 0, -34 },
  { 13381, 21, 42, 22, 3, -41 },
  { 13492, 32, 34, 36, 3, -33 },
  { 13628, 30, 33, 30, 3, -33 },
  { 13752, 45, 33, 46, 4, -33 },
  { 13938, 36, 33, 31, -3, -33 },
  { 14087, 38, 48, 30, -5, -33 },
  { 14315, 29, 33, 28, -1, -33 },
  { 14435, 25, 54, 22, 0, -44 },
  { 14604, 6, 62, 34, 15, -47 },
  { 14651, 25, 54, 22, -3, -44 },
  { 14820, 29, 9, 35, 4, -26 },
};

const GFXfont NotoSans_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_MEDIUMITALIC62PT7B_H_
