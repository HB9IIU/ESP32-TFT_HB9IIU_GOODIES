#ifndef _NOTOSANS_MEDIUMITALIC7PT7B_H_
#define _NOTOSANS_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x33, 0xD5, 0xE6, 0x00, 0x74, 0x66, 0xE0, 0xDE,
  0xF7, 0xB0, 0x72, 0x9B, 0x6F, 0x00, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95,
  0x80, 0xCF, 0x00, 0x2F, 0x20, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x75, 0x99,
  0x60, 0x75, 0x80, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x35, 0x6F, 0x20,
  0x74, 0x61, 0xE0, 0x34, 0x69, 0x60, 0x72, 0x24, 0xC0, 0x75, 0x69, 0xE0,
  0x69, 0x72, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xFF, 0xC3, 0xE0, 0xDA,
  0x80, 0x39, 0x5B, 0x75, 0xA9, 0xC0, 0x26, 0x5F, 0x90, 0x75, 0x69, 0xE0,
  0x34, 0x88, 0x70, 0x75, 0x59, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68, 0x80,
  0x3A, 0x25, 0x27, 0x00, 0x4A, 0x5D, 0x29, 0x00, 0x69, 0x2C, 0x24, 0xA5,
  0x80, 0x5B, 0x19, 0x49, 0x00, 0x49, 0x4E, 0x45, 0x37, 0x6E, 0xA8, 0x4B,
  0x5B, 0x29, 0x00, 0x72, 0x63, 0x17, 0x00, 0x75, 0x78, 0x80, 0x72, 0x63,
  0x17, 0x08, 0x75, 0x6A, 0x90, 0x74, 0x62, 0xE0, 0xEA, 0x48, 0x99, 0xAA,
  0xE0, 0xBA, 0xCC, 0x80, 0xA7, 0xAE, 0xA4, 0x90, 0x56, 0x26, 0xA0, 0xBB,
  0x48, 0x72, 0x44, 0xE0, 0x69, 0x49, 0x00, 0xF8, 0x24, 0x95, 0x80, 0x26,
  0x90, 0xE0, 0x80, 0x79, 0x9E, 0x46, 0x59, 0xE0, 0x72, 0x30, 0x17, 0x99,
  0xE0, 0x77, 0x30, 0x37, 0x24, 0x44, 0x80, 0x79, 0x9E, 0x2C, 0x47, 0x59,
  0xA0, 0x56, 0x80, 0x24, 0xA4, 0xA0, 0x45, 0x6A, 0xA0, 0x56, 0x80, 0x6D,
  0x59, 0x6A, 0x75, 0x9A, 0x69, 0x96, 0x65, 0x9E, 0x88, 0x79, 0x9E, 0x22,
  0x6A, 0x40, 0x71, 0xE0, 0x5D, 0x4C, 0x55, 0x9E, 0x9A, 0xA4, 0xAD, 0x54,
  0xA0, 0x56, 0x4A, 0x4A, 0x88, 0x42, 0x60, 0x65, 0x70, 0x29, 0x69, 0x80,
  0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 4, 5, 6, 1, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 1, -5 },
  { 19, 3, 6, 2, 0, -5 },
  { 22, 3, 6, 2, -1, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 5, 4, 1, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 2, 4, 0, -3 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 2, 5, 3, 1, -5 },
  { 73, 6, 6, 6, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 5, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 3, 0, -5 },
  { 96, 5, 5, 5, 0, -5 },
  { 100, 5, 5, 5, 0, -5 },
  { 104, 3, 5, 2, 0, -5 },
  { 106, 3, 6, 2, -1, -5 },
  { 109, 5, 5, 4, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 6, 5, 6, 0, -5 },
  { 119, 5, 5, 5, 0, -5 },
  { 123, 5, 5, 5, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 5, 6, 5, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 5, 4, 1, -5 },
  { 142, 4, 5, 5, 1, -5 },
  { 145, 4, 5, 4, 1, -5 },
  { 148, 6, 5, 6, 1, -5 },
  { 152, 4, 5, 4, 0, -5 },
  { 155, 3, 5, 4, 1, -5 },
  { 157, 4, 5, 4, 0, -5 },
  { 160, 3, 6, 2, 0, -5 },
  { 163, 1, 5, 3, 1, -5 },
  { 164, 3, 6, 2, -1, -5 },
  { 167, 4, 3, 4, 0, -5 },
  { 169, 3, 1, 3, -1, 0 },
  { 170, 1, 1, 2, 1, -5 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 3, 4, 4, 0, -4 },
  { 183, 4, 7, 2, -1, -5 },
  { 187, 4, 6, 4, 0, -4 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 2, 5, 2, 0, -5 },
  { 195, 3, 7, 2, -1, -5 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 2, 5, 2, 0, -5 },
  { 203, 6, 4, 6, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 5, 2, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 3, 0, -4 },
  { 226, 5, 4, 5, 0, -4 },
  { 229, 4, 4, 3, 0, -4 },
  { 231, 5, 6, 3, -1, -4 },
  { 235, 3, 4, 3, 0, -4 },
  { 237, 3, 6, 2, 0, -5 },
  { 240, 1, 7, 4, 2, -5 },
  { 241, 2, 6, 2, 0, -5 },
  { 243, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_MEDIUMITALIC7PT7B_H_
