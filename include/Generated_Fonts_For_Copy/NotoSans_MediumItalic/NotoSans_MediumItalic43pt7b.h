#ifndef _NOTOSANS_MEDIUMITALIC43PT7B_H_
#define _NOTOSANS_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x01, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x01, 0x00, 0x7C, 0x7B, 0xC3,
  0xDE, 0x3E, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xE0, 0xE7,
  0x0F, 0x38, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x03, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xCE,
  0x18, 0x3E, 0x38, 0x00, 0xF0, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00,
  0x3E, 0x70, 0x00, 0xFD, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x61, 0xE2, 0x03, 0x8F, 0x8E,
  0x0E, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3F, 0xC0, 0x03, 0xC1, 0xFF,
  0x80, 0x1E, 0x0F, 0x9F, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0x81, 0xE0, 0xF0,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0x70, 0x3C, 0x1C,
  0x03, 0xC0, 0xE0, 0xF0, 0x0F, 0x03, 0x87, 0x80, 0x3C, 0x1E, 0x3C, 0x00,
  0xF0, 0x78, 0xE1, 0xE3, 0xC1, 0xC7, 0x9F, 0xEF, 0x0F, 0x3C, 0xFF, 0xBE,
  0x79, 0xE7, 0xDF, 0x7F, 0xE7, 0x3E, 0x3D, 0xFF, 0x3C, 0xF0, 0xF1, 0xF1,
  0xE3, 0x81, 0xC0, 0x0F, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x3C, 0x01, 0xE1,
  0xE0, 0xF0, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x1C, 0x0F, 0x01, 0xE0, 0x70,
  0x78, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x07, 0x07, 0x03, 0xC0, 0x1E, 0x3C,
  0x0F, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0xFF, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xE3, 0xF3, 0xE0,
  0x7C, 0xF8, 0x7C, 0x0F, 0x3E, 0x07, 0xC3, 0xE7, 0xC0, 0x7C, 0xF8, 0xF0,
  0x0F, 0xDE, 0x3E, 0x00, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0xF8, 0x00, 0xFC,
  0x0F, 0x00, 0x3F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0x9F, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0x03, 0xF0, 0x7D, 0xE7, 0x9E,
  0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x07, 0x07, 0x80, 0x7C,
  0x70, 0x0F, 0xF7, 0x00, 0x7F, 0xF0, 0x70, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0x7F, 0x03, 0xB8, 0x00, 0xFB, 0x80, 0x1F, 0x3C, 0x03, 0xE3, 0xC0,
  0x7C, 0x1E, 0x01, 0xC1, 0xE0, 0x08, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0,
  0x78, 0x38, 0x3C, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x11,
  0xEF, 0xFF, 0xFB, 0xE6, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x7E,
  0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00,
  0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07,
  0xC3, 0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xDE, 0x3F, 0x3C, 0x38, 0xF8, 0x61, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x30, 0x07, 0xC0, 0x40, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0xF8,
  0x08, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x8C, 0x00, 0xFC,
  0x3F, 0x1F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0x80, 0x1F,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x81,
  0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE2, 0x00, 0x0F, 0x8C, 0x00, 0xFC, 0x3F, 0x1F, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x7F, 0x80, 0xF7, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xE1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x1E,
  0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0xEF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x40, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7C,
  0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x7E, 0x7E, 0x01, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFC, 0x7C, 0x1F,
  0x81, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01, 0xF0, 0xFC,
  0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F,
  0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFE, 0x78,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xE7, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF1, 0xF8, 0x78, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0, 0x60,
  0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0x81,
  0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x7F, 0xC1, 0xE1, 0xC0, 0x7F, 0xF8, 0x38, 0xF0, 0x3F, 0xFE,
  0x0F, 0x38, 0x1F, 0x07, 0x83, 0xDE, 0x0F, 0x01, 0xC0, 0xF7, 0x83, 0xC0,
  0xF0, 0x3D, 0xC1, 0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xBC, 0x1C,
  0x03, 0x80, 0xEF, 0x0F, 0x01, 0xE0, 0x7B, 0xC3, 0xC0, 0x78, 0x1E, 0xF0,
  0xF0, 0x3E, 0x0F, 0x3C, 0x3C, 0x0F, 0x83, 0xCF, 0x0F, 0x87, 0xE1, 0xE3,
  0xC1, 0xFF, 0xBF, 0xF0, 0x70, 0x7F, 0xCF, 0xF8, 0x1E, 0x0F, 0xE1, 0xFC,
  0x07, 0x80, 0x40, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0xFE, 0x07,
  0xC0, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3E,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78,
  0x01, 0xF8, 0x78, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0x0E, 0x07, 0xE0, 0x02, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x60, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0xE0, 0x3E, 0x01, 0xF8, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3C, 0x01, 0xFC, 0x1E,
  0x03, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0x81,
  0xF8, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xF3, 0xE0, 0x0F, 0xFC, 0xF8,
  0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x0F, 0x00, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xE0, 0x7E,
  0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00,
  0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xF7, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xBC, 0x0F,
  0x78, 0x00, 0xF7, 0x81, 0xE7, 0x00, 0x3C, 0xF0, 0x3C, 0xE0, 0x07, 0xBE,
  0x07, 0x9C, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xE7, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C,
  0x1E, 0x1E, 0x07, 0xC7, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0xF0, 0x78, 0x1E,
  0x0E, 0x1E, 0x1F, 0x03, 0xC1, 0xC7, 0x83, 0xE0, 0x78, 0x3C, 0xF0, 0x78,
  0x1F, 0x07, 0xBC, 0x0F, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x78, 0x1F, 0xE0,
  0x7C, 0x0F, 0x03, 0xFC, 0x0F, 0x83, 0xE0, 0x7F, 0x01, 0xE0, 0x7C, 0x0F,
  0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xE0, 0x1E, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x03, 0xC0,
  0xFC, 0x00, 0x3E, 0x0F, 0xE0, 0x01, 0xF0, 0x7F, 0x80, 0x0F, 0x03, 0xFC,
  0x00, 0x78, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0x3E, 0x0F, 0x3C, 0x01,
  0xF0, 0x79, 0xE0, 0x0F, 0x03, 0xCF, 0x80, 0x78, 0x1E, 0x3C, 0x03, 0xC1,
  0xF1, 0xE0, 0x3E, 0x0F, 0x8F, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x78, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x3E, 0x0F, 0x01, 0xF1,
  0xE0, 0x78, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x78, 0x1E, 0x01, 0xF3, 0xC1,
  0xF0, 0x07, 0xBE, 0x0F, 0x00, 0x3D, 0xE0, 0x78, 0x01, 0xFF, 0x03, 0xC0,
  0x07, 0xF8, 0x3E, 0x00, 0x3F, 0xC1, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x1F, 0xC0, 0xF8, 0x0F, 0xC1,
  0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0,
  0x7E, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0,
  0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x07, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xE0, 0x70, 0x3E, 0x00, 0x40, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x0C, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0xF0, 0x03, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x80, 0x1E,
  0x3C, 0x01, 0xFC, 0x01, 0xF1, 0xE0, 0x0F, 0xE0, 0x0F, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x78, 0x07, 0xF8, 0x07, 0x83, 0xC0, 0x7B, 0xC0, 0x7C, 0x1E,
  0x03, 0xCE, 0x03, 0xE0, 0xF0, 0x3C, 0x70, 0x3E, 0x07, 0x81, 0xE3, 0x81,
  0xF0, 0x3C, 0x1F, 0x1C, 0x0F, 0x01, 0xE0, 0xF0, 0xF0, 0xF8, 0x0F, 0x0F,
  0x87, 0x87, 0x80, 0x78, 0x78, 0x3C, 0x7C, 0x03, 0xC3, 0xC1, 0xE3, 0xC0,
  0x1E, 0x3C, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x07, 0xBC, 0x00, 0x7B, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF9,
  0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x78,
  0x7C, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x02, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E,
  0xF0, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x3C,
  0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x81, 0xE0, 0x0F, 0x07,
  0x00, 0x3C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xBC, 0x00,
  0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C,
  0x1E, 0x0E, 0x07, 0x00, 0x30, 0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xF3, 0xC3,
  0xFF, 0xFE, 0x0F, 0xC7, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80,
  0x7E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xF0, 0x7E, 0x7B,
  0xC1, 0xFF, 0xCF, 0x03, 0xFE, 0x38, 0x07, 0xF1, 0xE0, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x04,
  0x00, 0x78, 0xFE, 0x01, 0xE7, 0xFC, 0x0F, 0xBF, 0xF8, 0x3D, 0xE3, 0xE0,
  0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x1F,
  0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xFE, 0x3F, 0x07, 0xBF, 0xF8, 0x3C, 0xFF,
  0xC0, 0xF1, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xC1, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x08, 0x7F, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x10, 0x3C, 0x01, 0xFE, 0x7C, 0x03, 0xFF, 0x7C, 0x0F, 0xFF,
  0x78, 0x0F, 0xC7, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F,
  0xC0, 0x7E, 0x7B, 0xC0, 0x7F, 0xF3, 0xC0, 0x3F, 0xE3, 0x80, 0x1F, 0xC7,
  0x80, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC,
  0x3E, 0x3E, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x81,
  0xF9, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x87, 0xF0, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xBF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x3C, 0x0F, 0xFE, 0x78, 0x3F, 0xFF,
  0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x7F, 0x03, 0xF3,
  0xDE, 0x07, 0xFF, 0x7C, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x10, 0x03, 0xE0, 0x3F, 0x3F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x06, 0x00, 0x78, 0xFF, 0x01, 0xE7, 0xFE,
  0x0F, 0xBF, 0xF8, 0x3D, 0xE3, 0xF0, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x02, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x04, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x1F,
  0x00, 0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x3E, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xF1, 0xFC, 0x0F, 0xF0, 0x1C, 0x7F,
  0xC3, 0xFF, 0x07, 0x9F, 0xFC, 0xFF, 0xE0, 0xF7, 0x8F, 0xBC, 0x7C, 0x1F,
  0xC1, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE0,
  0x0F, 0x0F, 0x00, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x00, 0x7C, 0x7C, 0x01,
  0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x80, 0x3C, 0x3C,
  0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x80,
  0x3E, 0x3E, 0x00, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x3F, 0xC0, 0x79, 0xFF, 0x83, 0xCF, 0xFE, 0x0F, 0x78, 0xFC,
  0x3F, 0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x0F,
  0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x01, 0xE3, 0xF8, 0x01, 0xC7,
  0xFC, 0x03, 0xCF, 0xFE, 0x03, 0xDE, 0x3E, 0x03, 0xF8, 0x1F, 0x03, 0xF0,
  0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xE3, 0xF0, 0x1E, 0xFF, 0xF0, 0x3E, 0xFF,
  0xC0, 0x3E, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xF3, 0xC3, 0xFF, 0xFE, 0x0F, 0xC7, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C, 0x00, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x07, 0xF0, 0x7E, 0x7B, 0xC1, 0xFF, 0xDF, 0x03, 0xFE,
  0x78, 0x07, 0xF1, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x81, 0xE3,
  0xF0, 0x79, 0xF8, 0x3C, 0xFE, 0x0F, 0x7F, 0x83, 0xFC, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0x83, 0x87, 0xC0, 0x21, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF2, 0x00, 0x7C, 0xF0,
  0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x41, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81,
  0xFC, 0x1F, 0x1E, 0xF0, 0x7F, 0xF3, 0xC0, 0xFF, 0x8F, 0x01, 0xFC, 0x38,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x78, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x1E,
  0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x78, 0x07, 0xC0, 0x3E, 0x78, 0x0F,
  0xC0, 0x3C, 0x78, 0x0F, 0xE0, 0x7C, 0x78, 0x1F, 0xE0, 0x7C, 0x78, 0x1D,
  0xE0, 0xF8, 0x78, 0x3D, 0xE0, 0xF8, 0x78, 0x3D, 0xE0, 0xF0, 0x78, 0x79,
  0xE1, 0xF0, 0x78, 0x79, 0xE1, 0xE0, 0x78, 0x71, 0xE3, 0xE0, 0x78, 0xF1,
  0xE3, 0xC0, 0x78, 0xE1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0x80, 0x79, 0xE1,
  0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x00, 0x7B, 0xC1, 0xEF, 0x00, 0x7B, 0x81,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x1E, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0x9F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xE8,
  0x00, 0xF8,
};

const GFXglyph NotoSans_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 32, 12, 1, -31 },
  { 45, 13, 11, 18, 5, -31 },
  { 63, 27, 31, 28, 1, -31 },
  { 168, 22, 36, 24, 1, -33 },
  { 267, 30, 31, 35, 3, -31 },
  { 384, 27, 31, 29, 1, -31 },
  { 489, 6, 11, 10, 5, -31 },
  { 498, 14, 38, 13, 2, -31 },
  { 565, 14, 38, 13, -3, -31 },
  { 632, 20, 20, 24, 4, -33 },
  { 682, 20, 21, 25, 3, -26 },
  { 735, 9, 11, 11, -2, -5 },
  { 748, 11, 5, 14, 1, -14 },
  { 755, 6, 7, 11, 1, -6 },
  { 761, 22, 31, 16, -2, -31 },
  { 847, 21, 31, 24, 2, -31 },
  { 929, 15, 31, 24, 5, -31 },
  { 988, 23, 31, 24, 0, -31 },
  { 1078, 22, 31, 24, 1, -31 },
  { 1164, 23, 31, 24, 0, -31 },
  { 1254, 22, 31, 24, 1, -31 },
  { 1340, 22, 31, 24, 2, -31 },
  { 1426, 22, 31, 24, 3, -31 },
  { 1512, 21, 31, 24, 2, -31 },
  { 1594, 21, 31, 24, 2, -31 },
  { 1676, 9, 25, 11, 1, -24 },
  { 1705, 12, 30, 11, -2, -24 },
  { 1750, 20, 21, 25, 3, -26 },
  { 1803, 20, 12, 25, 3, -21 },
  { 1833, 20, 21, 25, 3, -26 },
  { 1886, 17, 32, 19, 3, -31 },
  { 1954, 34, 35, 37, 2, -31 },
  { 2103, 26, 31, 25, -3, -31 },
  { 2204, 24, 31, 26, 2, -31 },
  { 2297, 24, 31, 26, 3, -31 },
  { 2390, 25, 31, 29, 2, -31 },
  { 2487, 22, 31, 22, 2, -31 },
  { 2573, 22, 31, 21, 2, -31 },
  { 2659, 26, 31, 29, 3, -31 },
  { 2760, 28, 31, 30, 2, -31 },
  { 2869, 18, 31, 15, -1, -31 },
  { 2939, 20, 39, 13, -7, -31 },
  { 3037, 27, 31, 25, 2, -31 },
  { 3142, 16, 31, 21, 2, -31 },
  { 3204, 35, 31, 37, 2, -31 },
  { 3340, 29, 31, 31, 2, -31 },
  { 3453, 27, 31, 31, 3, -31 },
  { 3558, 23, 31, 25, 2, -31 },
  { 3648, 27, 38, 31, 3, -31 },
  { 3777, 23, 31, 25, 2, -31 },
  { 3867, 22, 31, 22, 1, -31 },
  { 3953, 22, 31, 22, 4, -31 },
  { 4039, 27, 31, 29, 3, -31 },
  { 4144, 24, 31, 24, 4, -31 },
  { 4237, 37, 31, 37, 4, -31 },
  { 4381, 29, 31, 24, -2, -31 },
  { 4494, 23, 31, 23, 4, -31 },
  { 4584, 26, 31, 23, -1, -31 },
  { 4685, 17, 38, 13, -1, -31 },
  { 4766, 8, 31, 16, 5, -31 },
  { 4797, 17, 38, 13, -3, -31 },
  { 4878, 22, 20, 24, 1, -31 },
  { 4933, 18, 3, 17, -4, 4 },
  { 4940, 8, 7, 13, 6, -33 },
  { 4947, 22, 24, 25, 2, -24 },
  { 5013, 22, 33, 25, 1, -33 },
  { 5104, 18, 24, 20, 2, -24 },
  { 5158, 24, 33, 25, 2, -33 },
  { 5257, 19, 24, 22, 2, -24 },
  { 5314, 25, 43, 14, -5, -33 },
  { 5449, 23, 34, 25, 1, -24 },
  { 5547, 22, 33, 25, 1, -33 },
  { 5638, 11, 32, 12, 1, -32 },
  { 5682, 17, 42, 12, -5, -32 },
  { 5772, 23, 33, 22, 1, -33 },
  { 5867, 12, 33, 12, 1, -33 },
  { 5917, 35, 24, 38, 1, -24 },
  { 6022, 22, 24, 25, 1, -24 },
  { 6088, 20, 24, 24, 2, -24 },
  { 6148, 24, 34, 25, -1, -24 },
  { 6250, 22, 34, 25, 2, -24 },
  { 6344, 18, 24, 17, 1, -24 },
  { 6398, 18, 24, 19, 0, -24 },
  { 6452, 14, 28, 15, 2, -28 },
  { 6501, 22, 23, 25, 2, -23 },
  { 6565, 21, 23, 21, 2, -23 },
  { 6626, 32, 23, 32, 2, -23 },
  { 6718, 25, 23, 21, -2, -23 },
  { 6790, 27, 33, 21, -4, -23 },
  { 6902, 20, 23, 19, -1, -23 },
  { 6960, 17, 38, 15, 0, -31 },
  { 7041, 3, 43, 24, 11, -33 },
  { 7058, 17, 38, 15, -2, -31 },
  { 7139, 20, 6, 25, 3, -18 },
};

const GFXfont NotoSans_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_MEDIUMITALIC43PT7B_H_
