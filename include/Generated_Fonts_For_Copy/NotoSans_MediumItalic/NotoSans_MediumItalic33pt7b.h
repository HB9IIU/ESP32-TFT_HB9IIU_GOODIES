#ifndef _NOTOSANS_MEDIUMITALIC33PT7B_H_
#define _NOTOSANS_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x38, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3,
  0x98, 0x63, 0x0C, 0xE3, 0x80, 0x00, 0x60, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x07,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xE1, 0xC0, 0x06, 0x0C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x79, 0x84, 0x38,
  0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0xB0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0x78, 0x01, 0x9E, 0x00, 0xCF, 0x00, 0xE7,
  0x90, 0x67, 0x8F, 0xBF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x1C, 0x1F, 0xC0, 0x38,
  0x3F, 0xE0, 0x38, 0x38, 0xE0, 0x70, 0x70, 0xE0, 0xE0, 0x70, 0xE1, 0xC0,
  0x70, 0xE1, 0xC0, 0x60, 0xE3, 0x80, 0xE0, 0xC7, 0x00, 0xE1, 0xCE, 0x00,
  0xE1, 0xCE, 0xFC, 0x63, 0x9D, 0xFE, 0x7F, 0xB9, 0xCE, 0x7F, 0x33, 0x87,
  0x1C, 0x73, 0x87, 0x00, 0xE7, 0x06, 0x01, 0xC7, 0x0E, 0x01, 0xC7, 0x0E,
  0x03, 0x87, 0x0E, 0x07, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0xBC,
  0x1C, 0x03, 0xF8, 0x38, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1C,
  0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x07, 0x9F, 0x78, 0x39, 0xE1, 0xC3, 0xCE, 0x0F, 0x1C,
  0xF0, 0x3D, 0xE7, 0x80, 0xFE, 0x3C, 0x07, 0xE1, 0xE0, 0x1E, 0x0F, 0x83,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xEF, 0x03, 0xFC, 0x3C, 0x3B, 0xDE, 0xE7,
  0x39, 0x8C, 0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x41, 0xC0, 0x71,
  0xC0, 0xFD, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0x07, 0xBE, 0x0F, 0xC0, 0x1C,
  0xC0, 0x3C, 0xE0, 0x78, 0xE0, 0x10, 0x70, 0x00, 0x70, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x78, 0xF3, 0xC7, 0x0E, 0x38, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xF0, 0x78,
  0xF0, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0xE0, 0x7C, 0x1F,
  0x8F, 0xE3, 0xFD, 0xFB, 0x9C, 0xF3, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE1,
  0xF1, 0xF0, 0x60, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFE,
  0x1F, 0xFF, 0x0E, 0x0F, 0x08, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x08, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x80, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0x70,
  0x03, 0x9C, 0x01, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x3C, 0x38, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xE1, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x40, 0x07,
  0xFE, 0x07, 0xFF, 0x81, 0x87, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x88, 0x07, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x79,
  0xF0, 0x77, 0xF8, 0x7F, 0xFC, 0xFC, 0x3C, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC8,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x1C, 0x38, 0x1E, 0x1C,
  0x0F, 0x0F, 0x0F, 0x07, 0xCF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0xF3, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x70, 0x0E, 0x78, 0x07, 0x3C, 0x03,
  0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0xC1, 0xF7, 0xEF, 0xE7,
  0xFF, 0xC7, 0xE7, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x1E, 0x7C, 0xF9, 0xE1,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE0,
  0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81,
  0xE0, 0x70, 0x38, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x0F, 0x87, 0xFE, 0xFF, 0xF7, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7C, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x70, 0x3F, 0x87, 0x70, 0x7F, 0xE3, 0xB8, 0x78, 0x70, 0xD8, 0x78, 0x70,
  0x7C, 0x38, 0x38, 0x3E, 0x38, 0x1C, 0x3F, 0x1C, 0x0E, 0x1F, 0x8E, 0x0E,
  0x0F, 0x87, 0x07, 0x06, 0xC3, 0x87, 0x87, 0x71, 0xC3, 0xC7, 0x38, 0xFF,
  0x7F, 0x9C, 0x3F, 0x3F, 0x0F, 0x02, 0x02, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xF3,
  0xC0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x3C, 0x78, 0x07,
  0x9E, 0x00, 0x73, 0xC0, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07,
  0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0x87, 0xE0, 0xF0, 0x3E,
  0x1E, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7,
  0x01, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0xE0, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x20, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x71, 0xFC, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0E, 0x00, 0xF0,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x38, 0x01,
  0xE3, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x70, 0x3F, 0x07, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0x1E, 0x0F, 0x80, 0x21, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x01, 0xFE, 0xF0, 0x1F, 0xEF,
  0x03, 0xFC, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0x78, 0x03, 0x87, 0x80, 0x38, 0x7C, 0x07, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x38, 0x07, 0x81, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x38, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3B, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xF1, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x01, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF0, 0xEC, 0x00, 0xFC, 0x1D,
  0xC0, 0x3B, 0x83, 0xB8, 0x07, 0x70, 0x77, 0x01, 0xDE, 0x1E, 0xE0, 0x3B,
  0xC3, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xCE, 0x0E, 0x70, 0x71, 0xC1, 0xCE,
  0x0E, 0x78, 0x79, 0xC3, 0x8F, 0x0E, 0x18, 0x71, 0xC1, 0xC3, 0x9C, 0x38,
  0x38, 0x77, 0x8F, 0x07, 0x0E, 0xE1, 0xE1, 0xE1, 0xFC, 0x38, 0x38, 0x3F,
  0x07, 0x07, 0x07, 0xC0, 0xE0, 0xE0, 0xF8, 0x3C, 0x3C, 0x1E, 0x07, 0x87,
  0x81, 0xC0, 0xE0, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x78,
  0x3E, 0x00, 0xE0, 0xFE, 0x01, 0xC1, 0xFC, 0x03, 0x83, 0xB8, 0x0F, 0x07,
  0x78, 0x1E, 0x1E, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x71, 0xE0, 0xE0, 0xE1,
  0xC3, 0xC1, 0xC3, 0x87, 0x07, 0x87, 0x8E, 0x0E, 0x07, 0x1C, 0x1C, 0x0E,
  0x78, 0x38, 0x1E, 0xF0, 0x70, 0x1D, 0xC1, 0xE0, 0x3F, 0x83, 0x80, 0x3F,
  0x07, 0x00, 0x7E, 0x0E, 0x00, 0xFC, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x87, 0xC0, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x7E,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x78, 0x70, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x87, 0xC0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1C,
  0x7E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x71, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x38, 0x0E, 0x0F, 0x07, 0x81, 0xC1, 0xE0,
  0x78, 0x78, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x0E, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x80, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC7,
  0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F,
  0x0E, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE,
  0x00, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00,
  0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x38,
  0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x7F, 0x80, 0x78, 0x07, 0xBC, 0x03, 0xC0, 0x3D, 0xE0, 0x3E, 0x01,
  0xC7, 0x01, 0xF0, 0x1E, 0x38, 0x1F, 0x80, 0xE1, 0xC0, 0xFC, 0x0F, 0x0E,
  0x0F, 0xE0, 0x70, 0x70, 0x73, 0x07, 0x83, 0x83, 0x9C, 0x38, 0x1C, 0x38,
  0xE1, 0xC0, 0xE1, 0xC7, 0x1E, 0x07, 0x1C, 0x38, 0xE0, 0x38, 0xE1, 0xCF,
  0x01, 0xCE, 0x0E, 0x70, 0x0E, 0x70, 0x77, 0x80, 0x77, 0x03, 0xB8, 0x03,
  0xB8, 0x1D, 0xC0, 0x1D, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x0E, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x03,
  0xCF, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0x70, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0xF8, 0x03, 0xDC, 0x03, 0xCE, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xE1,
  0xE0, 0x70, 0xF0, 0x38, 0xF0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x18, 0xE0, 0x1C, 0x70,
  0x0C, 0x1C, 0x0E, 0x0E, 0x06, 0x03, 0x07, 0x01, 0xC3, 0x00, 0xE3, 0x80,
  0x3B, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xC7, 0x8E, 0x1C, 0x07,
  0xC3, 0x0F, 0xF7, 0x1F, 0xF7, 0x3E, 0x3F, 0x7C, 0x1F, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x7C, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xB8, 0x3E, 0x38, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0xF8, 0x1E, 0xFE, 0x0E, 0xFF, 0x87, 0xE3, 0xC3, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38, 0x07, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC1, 0xE3, 0xBF, 0xF1,
  0xDF, 0xF0, 0xE7, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0x82,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x02, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x1C, 0x0F, 0xF7, 0x07, 0xFD, 0xC3,
  0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x7C,
  0x3C, 0x3E, 0x0F, 0xFF, 0x81, 0xFE, 0xE0, 0x3E, 0x38, 0x00, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x1D, 0xE0, 0xFF, 0x03, 0xFC, 0x7E,
  0xFF, 0xF3, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01,
  0x3F, 0x7C, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF1, 0x83, 0xFD, 0xC3, 0xFE, 0xE3, 0xE1, 0xF3, 0xC0, 0xF9,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xF1, 0xE1, 0xF0, 0xFF, 0xB8, 0x3F,
  0xDC, 0x0F, 0x9E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC3,
  0x03, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x7C, 0x1E, 0xFF, 0x0E, 0xFF, 0x87, 0xE1, 0xC3, 0xE0, 0xF3, 0xE0,
  0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x38,
  0xE0, 0x3C, 0x00, 0x02, 0x07, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x0F, 0x03, 0x8F, 0x03,
  0xCF, 0x01, 0xEF, 0x00, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3E, 0xF0,
  0x1E, 0x78, 0x0E, 0x1E, 0x07, 0x0F, 0x03, 0x83, 0xC3, 0xC1, 0xE1, 0xE0,
  0x70, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x0C, 0x7C, 0x1F,
  0x07, 0x3F, 0x8F, 0xF1, 0xDF, 0xF7, 0xFC, 0x7E, 0x3F, 0x87, 0x1F, 0x07,
  0xC1, 0xCF, 0x81, 0xE0, 0x73, 0xC0, 0xF0, 0x1C, 0xF0, 0x3C, 0x0F, 0x38,
  0x0F, 0x03, 0xCE, 0x03, 0x80, 0xF7, 0x80, 0xE0, 0x39, 0xE0, 0x78, 0x0E,
  0x70, 0x1E, 0x07, 0x9C, 0x07, 0x01, 0xE7, 0x01, 0xC0, 0x7B, 0xC0, 0x70,
  0x1C, 0xF0, 0x3C, 0x07, 0x38, 0x0F, 0x03, 0xC0, 0x1C, 0x7E, 0x0E, 0x7F,
  0x87, 0x7F, 0xC3, 0xF0, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF0, 0x1C, 0x78,
  0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x1E, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF7, 0x81, 0xEF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xDC,
  0x07, 0xBC, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x03, 0x1F, 0x00,
  0xE7, 0xF0, 0x1D, 0xFF, 0x03, 0xF1, 0xE0, 0x78, 0x1E, 0x1F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0x3F, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE3, 0x0F, 0xF7, 0x1F, 0xF7, 0x3C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x7C, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xB8, 0x3E, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x0C, 0x78, 0xE7, 0xC7, 0x7E, 0x3F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xF1, 0xFF, 0x8F, 0x02, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC8, 0x0F, 0x3E,
  0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1F,
  0xF7, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x03, 0xE3, 0xC3, 0xE1, 0xFF, 0xF0,
  0xFF, 0xB8, 0x3F, 0x1C, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0,
  0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x71, 0xE0, 0x71,
  0xE0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0E, 0xE0,
  0x7C, 0x1E, 0xE0, 0xFC, 0x1C, 0xE0, 0xFC, 0x3C, 0xE1, 0xDC, 0x38, 0xE1,
  0xDC, 0x78, 0xE3, 0x9C, 0x78, 0xE3, 0x9C, 0x70, 0xE3, 0x9C, 0xF0, 0xE7,
  0x1C, 0xE0, 0xE7, 0x1D, 0xE0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0x6C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x0E,
  0x03, 0xE1, 0xE0, 0xF8, 0x1C, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x07,
  0x78, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x01, 0xE1,
  0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x38, 0x07, 0x81,
  0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x0E,
  0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE7, 0x80, 0x07,
  0x38, 0x00, 0x39, 0xC0, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0x08, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x3F, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xF4, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFE,
  0x80, 0x38,
};

const GFXglyph NotoSans_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 24, 9, 1, -24 },
  { 28, 11, 9, 14, 3, -24 },
  { 41, 21, 24, 21, 1, -24 },
  { 104, 17, 27, 18, 1, -25 },
  { 162, 24, 24, 27, 2, -24 },
  { 234, 21, 24, 23, 1, -24 },
  { 297, 5, 9, 8, 3, -24 },
  { 303, 12, 29, 10, 1, -24 },
  { 347, 11, 29, 10, -2, -24 },
  { 387, 16, 15, 18, 3, -25 },
  { 417, 16, 16, 19, 2, -20 },
  { 449, 7, 8, 9, -1, -4 },
  { 456, 8, 3, 10, 1, -10 },
  { 459, 4, 4, 9, 1, -4 },
  { 461, 17, 24, 12, -2, -24 },
  { 512, 16, 24, 18, 2, -24 },
  { 560, 11, 24, 18, 4, -24 },
  { 593, 17, 24, 18, 0, -24 },
  { 644, 16, 24, 18, 1, -24 },
  { 692, 18, 24, 18, 0, -24 },
  { 746, 17, 24, 18, 1, -24 },
  { 797, 16, 24, 18, 2, -24 },
  { 845, 17, 24, 18, 2, -24 },
  { 896, 17, 24, 18, 1, -24 },
  { 947, 15, 24, 18, 2, -24 },
  { 992, 7, 18, 9, 1, -18 },
  { 1008, 10, 22, 9, -2, -18 },
  { 1036, 16, 16, 19, 2, -20 },
  { 1068, 16, 9, 19, 2, -16 },
  { 1086, 16, 16, 19, 2, -20 },
  { 1118, 12, 24, 14, 3, -24 },
  { 1154, 25, 27, 28, 2, -24 },
  { 1239, 19, 24, 19, -2, -24 },
  { 1296, 19, 24, 20, 1, -24 },
  { 1353, 19, 24, 20, 2, -24 },
  { 1410, 20, 24, 22, 1, -24 },
  { 1470, 18, 24, 17, 1, -24 },
  { 1524, 17, 24, 16, 1, -24 },
  { 1575, 20, 24, 23, 2, -24 },
  { 1635, 22, 24, 23, 1, -24 },
  { 1701, 14, 24, 11, -1, -24 },
  { 1743, 15, 30, 10, -5, -24 },
  { 1800, 21, 24, 19, 1, -24 },
  { 1863, 13, 24, 16, 1, -24 },
  { 1902, 27, 24, 28, 1, -24 },
  { 1983, 23, 24, 24, 1, -24 },
  { 2052, 21, 24, 24, 2, -24 },
  { 2115, 18, 24, 19, 1, -24 },
  { 2169, 21, 30, 24, 2, -24 },
  { 2248, 18, 24, 19, 1, -24 },
  { 2302, 16, 24, 17, 1, -24 },
  { 2350, 17, 24, 17, 3, -24 },
  { 2401, 20, 24, 22, 3, -24 },
  { 2461, 19, 24, 19, 3, -24 },
  { 2518, 29, 24, 29, 3, -24 },
  { 2605, 23, 24, 18, -2, -24 },
  { 2674, 17, 24, 17, 3, -24 },
  { 2725, 20, 24, 18, -1, -24 },
  { 2785, 13, 29, 10, 0, -24 },
  { 2833, 6, 24, 12, 4, -24 },
  { 2851, 13, 29, 10, -2, -24 },
  { 2899, 17, 15, 19, 1, -24 },
  { 2931, 14, 2, 13, -3, 3 },
  { 2935, 6, 5, 10, 5, -25 },
  { 2939, 16, 18, 19, 2, -18 },
  { 2975, 17, 25, 19, 1, -25 },
  { 3029, 14, 18, 15, 2, -18 },
  { 3061, 18, 25, 19, 2, -25 },
  { 3118, 14, 18, 17, 2, -18 },
  { 3150, 19, 33, 11, -4, -25 },
  { 3229, 17, 26, 19, 1, -18 },
  { 3285, 17, 25, 19, 1, -25 },
  { 3339, 8, 25, 9, 1, -25 },
  { 3364, 13, 33, 9, -4, -25 },
  { 3418, 17, 25, 17, 1, -25 },
  { 3472, 9, 25, 9, 1, -25 },
  { 3501, 26, 18, 29, 1, -18 },
  { 3560, 17, 18, 19, 1, -18 },
  { 3599, 15, 18, 19, 2, -18 },
  { 3633, 19, 26, 19, -1, -18 },
  { 3695, 16, 26, 19, 2, -18 },
  { 3747, 13, 18, 13, 1, -18 },
  { 3777, 14, 18, 15, 0, -18 },
  { 3809, 12, 22, 12, 1, -22 },
  { 3842, 17, 18, 19, 2, -18 },
  { 3881, 16, 18, 16, 2, -18 },
  { 3917, 24, 18, 24, 2, -18 },
  { 3971, 19, 18, 16, -1, -18 },
  { 4014, 21, 26, 16, -3, -18 },
  { 4083, 16, 18, 15, -1, -18 },
  { 4119, 13, 29, 12, 0, -24 },
  { 4167, 3, 33, 18, 8, -25 },
  { 4180, 13, 29, 12, -1, -24 },
  { 4228, 16, 5, 19, 2, -14 },
};

const GFXfont NotoSans_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_MEDIUMITALIC33PT7B_H_
