#ifndef _NOTOSANS_MEDIUMITALIC19PT7B_H_
#define _NOTOSANS_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x23, 0x00, 0x0E, 0x70, 0x6D, 0x3C,
  0xF2, 0xD8, 0x04, 0x41, 0x98, 0x33, 0x04, 0x47, 0xFE, 0xFF, 0xC4, 0x40,
  0x88, 0x33, 0x1F, 0xF8, 0x88, 0x33, 0x06, 0x60, 0x88, 0x00, 0x06, 0x0F,
  0x8F, 0xEC, 0x86, 0xC3, 0x60, 0xF0, 0x3C, 0x0B, 0x0D, 0x84, 0xDF, 0xCF,
  0xC0, 0x80, 0xC0, 0x18, 0x18, 0xF0, 0xC6, 0x42, 0x11, 0x18, 0x44, 0xC3,
  0x36, 0x0C, 0xD7, 0x9E, 0xD3, 0x36, 0xCC, 0x33, 0x30, 0x88, 0x86, 0x26,
  0x30, 0xD9, 0x83, 0xC0, 0x0F, 0x01, 0xF8, 0x31, 0x83, 0x18, 0x31, 0x81,
  0xF0, 0x1C, 0x07, 0xC7, 0xEE, 0x6C, 0x6C, 0xC3, 0xCC, 0x38, 0xEF, 0xC7,
  0xCE, 0x6B, 0x6C, 0x0C, 0x61, 0x8C, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x60, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31,
  0x86, 0x18, 0xC2, 0x18, 0xC0, 0x08, 0x06, 0x23, 0x1D, 0x07, 0xF8, 0xFC,
  0xF1, 0xD8, 0x46, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x36, 0x6C, 0x7F, 0xC0, 0xFC, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x00, 0x0E, 0x0F, 0x8C, 0x6C, 0x36, 0x1F, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xF0, 0xD8, 0xE7, 0xE3, 0xE0, 0x06, 0x38, 0xF7, 0x64, 0xC1, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x00, 0x07, 0x0F, 0xE1, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF,
  0xE0, 0x07, 0x0F, 0xF1, 0x0C, 0x03, 0x00, 0xC0, 0x61, 0xF0, 0x7C, 0x03,
  0x80, 0x60, 0x18, 0x06, 0xEF, 0x3F, 0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1A,
  0x0D, 0x83, 0x61, 0x98, 0xC6, 0x63, 0x3F, 0xFF, 0xFC, 0x0C, 0x02, 0x01,
  0x80, 0x1F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0x01, 0xF8, 0x8E, 0x03, 0x01,
  0x80, 0xC0, 0xED, 0xE7, 0xE0, 0x03, 0x87, 0xC6, 0x06, 0x06, 0x03, 0x21,
  0x7D, 0xC6, 0xC1, 0xE0, 0xF0, 0xD8, 0x67, 0xE3, 0xE0, 0x7F, 0xDF, 0xF0,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x00, 0x0F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x98, 0x78, 0x7C,
  0x63, 0x61, 0xB0, 0xD8, 0x6E, 0x73, 0xF0, 0x0E, 0x1F, 0x9C, 0xEC, 0x36,
  0x1F, 0x0D, 0x8E, 0xFF, 0x3F, 0x01, 0x80, 0xC0, 0xCF, 0xC7, 0xC0, 0x39,
  0x80, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x31, 0x86, 0x30, 0x00, 0x80, 0xC1, 0xC3, 0x87, 0x07, 0x00, 0xE0, 0x1E,
  0x03, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0C, 0x3C, 0x78, 0xE0, 0x40, 0x00, 0x1C, 0x7E, 0x43,
  0x03, 0x03, 0x06, 0x1C, 0x38, 0x30, 0x60, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0xC0, 0x1F, 0xF0, 0x70, 0x71, 0x80, 0x66, 0x1E, 0x68, 0xEC, 0xF3, 0x19,
  0xE4, 0x23, 0xC8, 0xC5, 0x91, 0x9B, 0x35, 0x66, 0x7B, 0x84, 0x00, 0x0E,
  0x04, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0x80, 0x38, 0x0F, 0x01, 0x60, 0x6C,
  0x19, 0x83, 0x30, 0xC6, 0x1F, 0xC7, 0xFC, 0xC1, 0xB0, 0x36, 0x07, 0x80,
  0xC0, 0x1E, 0x0F, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x77, 0xF9, 0xFC, 0x61,
  0x98, 0x6C, 0x1B, 0x06, 0xFF, 0x3F, 0x80, 0x03, 0xC1, 0xFC, 0x70, 0x98,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0xF8, 0x7F, 0x00, 0x1E, 0x07, 0xF0, 0xC7, 0x18, 0x73, 0x06, 0x60, 0xD8,
  0x1B, 0x03, 0x60, 0x6C, 0x1B, 0x07, 0x61, 0xCF, 0xF1, 0xF8, 0x00, 0x1F,
  0xCF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0xF1, 0xFC, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE3, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0xFC, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0xC0, 0xFF, 0x1C, 0x23, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x3E, 0xC0,
  0x6C, 0x0C, 0xE0, 0xC6, 0x0C, 0x7F, 0xC1, 0xF8, 0x18, 0x33, 0x03, 0x30,
  0x33, 0x06, 0x30, 0x63, 0x06, 0x7F, 0xE7, 0xFE, 0x60, 0xC6, 0x0C, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0x3F, 0x3E, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0xF8, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0xF8, 0x70, 0x00, 0x18, 0x73, 0x0E, 0x31, 0xC3, 0x38, 0x37, 0x03,
  0xE0, 0x6C, 0x07, 0xC0, 0x66, 0x06, 0x60, 0xC7, 0x0C, 0x30, 0xC3, 0x0C,
  0x18, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0F,
  0xFF, 0xC0, 0x18, 0x0E, 0x70, 0x1C, 0xF0, 0x79, 0xE0, 0xB3, 0xC3, 0x4D,
  0x85, 0x9B, 0x1B, 0x36, 0x26, 0x64, 0xCC, 0xCB, 0x33, 0x16, 0x66, 0x38,
  0xCC, 0x71, 0x98, 0xC7, 0x00, 0x18, 0x19, 0xC0, 0xCF, 0x0C, 0x78, 0x63,
  0xC3, 0x33, 0x19, 0x98, 0xCC, 0xCC, 0x63, 0x63, 0x1B, 0x30, 0xD9, 0x83,
  0x8C, 0x1C, 0x60, 0x60, 0x07, 0x81, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x36,
  0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x66, 0x0E, 0x7F, 0xC3,
  0xF0, 0x1E, 0x0F, 0xE3, 0x1C, 0xC3, 0x30, 0xCC, 0x36, 0x19, 0xFE, 0x7E,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x81, 0xFE, 0x38, 0x63,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x66,
  0x0C, 0x7F, 0xC3, 0xF0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x0F, 0xE3,
  0x1C, 0xC3, 0x30, 0xCC, 0x36, 0x39, 0xFC, 0x7E, 0x19, 0x8C, 0x33, 0x0C,
  0xC3, 0x30, 0x60, 0x07, 0x87, 0xF3, 0x84, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x0C, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xC6,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x00, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0xCE, 0x0C, 0xC0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0xC0, 0xF0,
  0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0x4C, 0x1B, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x86, 0xC3, 0x86,
  0xC6, 0x8C, 0xC6, 0x8C, 0xCC, 0x98, 0xCC, 0x98, 0xD8, 0x98, 0xD8, 0xB0,
  0xD0, 0xB0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0x18, 0x18, 0x61, 0x83,
  0x18, 0x19, 0xC0, 0x6C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xEC,
  0x06, 0x60, 0x63, 0x86, 0x0C, 0x70, 0x60, 0xC1, 0xF0, 0x6C, 0x31, 0x1C,
  0x66, 0x1B, 0x06, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x00, 0x1F, 0xE7, 0xFC, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0F, 0xF9, 0xFE, 0x00, 0x1E, 0x3C, 0x60,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x78, 0xF0,
  0xCC, 0xC4, 0x46, 0x66, 0x66, 0x22, 0x33, 0x1E, 0x3C, 0x18, 0x20, 0xC1,
  0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x78, 0xF0, 0x08, 0x06,
  0x07, 0x06, 0xC3, 0x63, 0x19, 0x8D, 0x82, 0xC1, 0x80, 0xFF, 0xD9, 0x80,
  0x3E, 0xDC, 0xE6, 0x1B, 0x86, 0xC1, 0xB0, 0xCC, 0x33, 0x1C, 0xEF, 0x1E,
  0xC0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x37, 0x8F, 0x33, 0x8C, 0xC3, 0x30,
  0xD8, 0x36, 0x1D, 0x86, 0x7F, 0xB7, 0x80, 0x3F, 0x71, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3E, 0x9C,
  0xE6, 0x1B, 0x86, 0xC1, 0xB0, 0xCC, 0x33, 0x1C, 0xEF, 0x1E, 0xC0, 0x3F,
  0x73, 0x63, 0xC3, 0xFE, 0xF8, 0xC0, 0xC0, 0xE6, 0x7E, 0x00, 0x80, 0x7C,
  0x0C, 0x03, 0x00, 0x60, 0x3F, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x03, 0xC0, 0x60,
  0x00, 0x1F, 0x67, 0x38, 0xC3, 0x38, 0x66, 0x0C, 0xC3, 0x18, 0x63, 0x1C,
  0x77, 0x87, 0xB0, 0x0C, 0x01, 0x88, 0x71, 0xFC, 0x0C, 0x00, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x37, 0xCF, 0x33, 0x8C, 0xC3, 0x30, 0xD8, 0x36, 0x19,
  0x86, 0x61, 0xB8, 0x60, 0x18, 0xC0, 0x03, 0x98, 0xC6, 0x33, 0x18, 0xC6,
  0x70, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x31, 0xC3, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x31,
  0xCC, 0xE3, 0x70, 0xD8, 0x2C, 0x1F, 0x86, 0x61, 0x9C, 0x63, 0x38, 0xE0,
  0x1C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x80, 0x37,
  0x9E, 0x3C, 0xF7, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC6, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x86, 0xE3, 0x0C, 0x37, 0xCF, 0x33, 0x8C, 0xC3,
  0x30, 0xD8, 0x36, 0x19, 0x86, 0x61, 0xB8, 0x60, 0x3F, 0x39, 0x98, 0x78,
  0x3C, 0x1E, 0x0F, 0x0D, 0x86, 0xFE, 0x3E, 0x00, 0x17, 0x8F, 0x33, 0x8C,
  0xC3, 0x30, 0xD8, 0x36, 0x1D, 0x86, 0x7F, 0x9F, 0x8C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x3E, 0xDC, 0xE6, 0x1B, 0x86, 0xC1, 0xB0, 0xCC, 0x33,
  0x1C, 0xEF, 0x1E, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x37, 0x3D,
  0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x3F, 0x71, 0x60, 0x70,
  0x3C, 0x0E, 0x06, 0x06, 0xCE, 0xFC, 0x10, 0xC3, 0x3F, 0x61, 0x86, 0x18,
  0xC3, 0x0C, 0x3A, 0x70, 0x70, 0xD8, 0x66, 0x19, 0x86, 0x61, 0xB0, 0xCC,
  0x33, 0x1C, 0xEF, 0x1E, 0xC0, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0xE2, 0x61,
  0xE0, 0xF0, 0x70, 0x38, 0x00, 0xC7, 0x1F, 0x1C, 0x6C, 0x51, 0xB3, 0x4C,
  0xC9, 0x33, 0x65, 0x8D, 0x16, 0x3C, 0x50, 0xF1, 0xC1, 0x86, 0x00, 0x38,
  0xE3, 0x38, 0x36, 0x07, 0x80, 0x60, 0x1C, 0x06, 0xC1, 0x98, 0x73, 0x1C,
  0x30, 0x18, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x0C, 0xC0, 0xD8, 0x0D, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0x40, 0x00,
  0x3F, 0x81, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7F, 0x00,
  0x03, 0x0E, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0xE0, 0x70, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xE0, 0x10, 0x1C, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x10, 0x30, 0x30, 0xF0,
  0xE0, 0x78, 0xFF, 0xE0, 0xC0,
};

const GFXglyph NotoSans_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 8, 2, -14 },
  { 14, 11, 14, 12, 1, -14 },
  { 34, 9, 15, 10, 1, -14 },
  { 51, 14, 14, 16, 1, -14 },
  { 76, 12, 14, 13, 1, -14 },
  { 97, 3, 5, 4, 2, -14 },
  { 99, 6, 17, 6, 1, -14 },
  { 112, 6, 17, 6, -1, -14 },
  { 125, 9, 9, 10, 2, -15 },
  { 136, 9, 9, 11, 1, -11 },
  { 147, 4, 4, 5, -1, -2 },
  { 149, 5, 2, 6, 0, -6 },
  { 151, 3, 2, 5, 0, -2 },
  { 152, 10, 14, 7, -1, -14 },
  { 170, 9, 14, 10, 1, -14 },
  { 186, 7, 14, 10, 2, -14 },
  { 199, 10, 14, 10, 0, -14 },
  { 217, 10, 14, 10, 0, -14 },
  { 235, 10, 14, 10, 0, -14 },
  { 253, 9, 14, 10, 1, -14 },
  { 269, 9, 14, 10, 1, -14 },
  { 285, 10, 14, 10, 1, -14 },
  { 303, 9, 14, 10, 1, -14 },
  { 319, 9, 14, 10, 1, -14 },
  { 335, 5, 10, 5, 0, -10 },
  { 342, 6, 12, 5, -1, -10 },
  { 351, 9, 10, 11, 1, -12 },
  { 363, 9, 5, 11, 1, -9 },
  { 369, 9, 10, 11, 1, -12 },
  { 381, 8, 14, 8, 1, -14 },
  { 395, 15, 16, 16, 1, -14 },
  { 425, 11, 14, 11, -1, -14 },
  { 445, 10, 14, 12, 1, -14 },
  { 463, 11, 14, 11, 1, -14 },
  { 483, 11, 14, 13, 1, -14 },
  { 503, 10, 14, 10, 1, -14 },
  { 521, 10, 14, 9, 1, -14 },
  { 539, 12, 14, 13, 1, -14 },
  { 560, 12, 14, 13, 1, -14 },
  { 581, 8, 14, 6, 0, -14 },
  { 595, 9, 18, 6, -3, -14 },
  { 616, 12, 14, 11, 1, -14 },
  { 637, 7, 14, 9, 1, -14 },
  { 650, 15, 14, 16, 1, -14 },
  { 677, 13, 14, 14, 1, -14 },
  { 700, 12, 14, 14, 1, -14 },
  { 721, 10, 14, 11, 1, -14 },
  { 739, 12, 17, 14, 1, -14 },
  { 765, 10, 14, 11, 1, -14 },
  { 783, 10, 14, 10, 0, -14 },
  { 801, 9, 14, 10, 2, -14 },
  { 817, 12, 14, 13, 1, -14 },
  { 838, 10, 14, 11, 2, -14 },
  { 856, 16, 14, 16, 2, -14 },
  { 884, 13, 14, 10, -1, -14 },
  { 907, 10, 14, 10, 2, -14 },
  { 925, 11, 14, 10, 0, -14 },
  { 945, 7, 17, 6, 0, -14 },
  { 960, 4, 14, 7, 2, -14 },
  { 967, 7, 17, 6, -1, -14 },
  { 982, 9, 9, 11, 1, -14 },
  { 993, 8, 1, 8, -2, 2 },
  { 994, 3, 3, 6, 3, -15 },
  { 996, 10, 10, 11, 1, -10 },
  { 1009, 10, 14, 11, 0, -14 },
  { 1027, 8, 10, 9, 1, -10 },
  { 1037, 10, 14, 11, 1, -14 },
  { 1055, 8, 10, 10, 1, -10 },
  { 1065, 11, 20, 6, -2, -15 },
  { 1093, 11, 15, 11, 0, -10 },
  { 1114, 10, 14, 11, 0, -14 },
  { 1132, 5, 14, 5, 0, -14 },
  { 1141, 7, 19, 5, -2, -14 },
  { 1158, 10, 14, 10, 0, -14 },
  { 1176, 6, 14, 5, 0, -14 },
  { 1187, 16, 10, 17, 0, -10 },
  { 1207, 10, 10, 11, 0, -10 },
  { 1220, 9, 10, 11, 1, -10 },
  { 1232, 10, 15, 11, 0, -10 },
  { 1251, 10, 15, 11, 1, -10 },
  { 1270, 8, 10, 8, 0, -10 },
  { 1280, 8, 10, 8, 0, -10 },
  { 1290, 6, 13, 7, 1, -13 },
  { 1300, 10, 10, 11, 1, -10 },
  { 1313, 9, 10, 9, 1, -10 },
  { 1325, 14, 10, 14, 1, -10 },
  { 1343, 11, 10, 9, -1, -10 },
  { 1357, 12, 15, 9, -2, -10 },
  { 1380, 9, 10, 9, 0, -10 },
  { 1392, 8, 17, 7, 0, -14 },
  { 1409, 1, 19, 10, 5, -14 },
  { 1412, 8, 17, 7, -1, -14 },
  { 1429, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_MEDIUMITALIC19PT7B_H_
