#ifndef _NOTOSANS_MEDIUMITALIC64PT7B_H_
#define _NOTOSANS_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x07,
  0xF3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x3C, 0xFC, 0x03, 0xFC, 0x7C, 0x1C, 0x03, 0xF8, 0x78, 0x04, 0x03, 0xF0,
  0x78, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x07, 0xF0,
  0xF8, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x03, 0xF8,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07,
  0x83, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x0F, 0x87, 0xF0, 0x80, 0x0F, 0x07, 0xF0, 0xC0, 0x0F,
  0x0F, 0xE0, 0xF8, 0x0F, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x3F,
  0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F, 0x87,
  0xE3, 0xFF, 0x8F, 0x80, 0xFC, 0x7E, 0x3F, 0xFE, 0x7E, 0x0F, 0xC7, 0xE3,
  0xFF, 0xF3, 0xF0, 0xFC, 0x3E, 0x3F, 0xFF, 0xDF, 0xFF, 0xE3, 0xF3, 0xF8,
  0x7E, 0x7F, 0xFE, 0x3F, 0x1F, 0x81, 0xF3, 0xFF, 0xE3, 0xF1, 0xF8, 0x0F,
  0x8F, 0xFE, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0xE1, 0xF8, 0x7C, 0x03, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x00,
  0x0F, 0x81, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x00, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xF9, 0xFE, 0x00, 0x7E, 0x1F, 0xF0, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x81, 0xFC,
  0x7F, 0x80, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x00,
  0x1F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x00, 0x07,
  0xFC, 0x3C, 0x00, 0x3F, 0xFC, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x78,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x70, 0x0F, 0xE0, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x3F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xF3, 0xF8, 0xFF, 0x1F, 0xC3, 0xE0, 0xFE,
  0x1C, 0x07, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0xE0, 0x00, 0xFF, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x3F, 0xC1,
  0xE0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x82, 0x00, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0xFF, 0xC0, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xC3, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFC, 0x3F, 0xFC, 0x01, 0xF9, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xFF, 0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFD,
  0xF8, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0x1F,
  0xC0, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x1F, 0xF8, 0xF8, 0x03, 0xFC, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0xF0,
  0xFE, 0x01, 0xF3, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0xFC, 0x07, 0xF0,
  0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xDF, 0x80, 0xFC,
  0x00, 0xFC, 0x01, 0xF7, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7D, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x3F, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xDF, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x7C, 0x00, 0x7E, 0x00, 0xFB, 0xF0,
  0x3F, 0x00, 0x1F, 0x00, 0x7E, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xBF,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xCF, 0xC0, 0xFC, 0x01, 0xFC, 0x03, 0xF3,
  0xF0, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x07, 0xC0, 0x7F, 0x1F, 0xFE, 0x3F,
  0x81, 0xF0, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xE3, 0xFF,
  0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x1F, 0xF8, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x1F,
  0xC0, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x0F,
  0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0x87,
  0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0x7C, 0x00, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE1,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07,
  0xC0, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7F, 0x00, 0x3F,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x3E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFD, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x08, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x02, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xF7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF1, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1,
  0xFC, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0x87, 0xF0, 0x00,
  0x7E, 0x3F, 0x80, 0x3E, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x03, 0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xC0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xFE,
  0x0F, 0xC0, 0x1F, 0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF,
  0xFB, 0xF0, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xFF, 0x9F,
  0x00, 0x7F, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0x87,
  0xE0, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x7F, 0xF0, 0x03, 0xF8, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFC, 0x03, 0xFB,
  0xFF, 0xFE, 0x03, 0xF7, 0xF7, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0x00, 0xF8, 0x3F, 0xFE, 0x00, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x20, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x40, 0xFF, 0xC0, 0x78, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x7F, 0xFE, 0x3F,
  0x00, 0x0F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0xFB,
  0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x3F,
  0x7E, 0x00, 0x7F, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0x3F,
  0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFE, 0x7F, 0x00, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x07, 0xFC,
  0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x87, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xFE, 0x1F,
  0x00, 0x1F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFF,
  0xDF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0xE7, 0xF0, 0x00,
  0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0x08, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x0F,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xF8, 0x03, 0xF8, 0xFF, 0xFC, 0x03, 0xF9,
  0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x21,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x07,
  0xEF, 0xEF, 0xF9, 0xFE, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xBE, 0x07, 0xF8,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0xF0, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x7E, 0x1F, 0xFF, 0x80,
  0x3F, 0x1F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xFC,
  0x07, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x3F,
  0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xF0,
  0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x3F, 0x3F,
  0xFF, 0xE0, 0x03, 0xF7, 0xF7, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0xFF, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0xFE, 0x00,
  0x0F, 0xC1, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0x87,
  0xC0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFD, 0xFD,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x03,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0x9F, 0x80,
  0x3F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x07, 0xE0,
  0x00, 0x1C, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x1F, 0xF0, 0x3F, 0x0F,
  0xFC, 0x0F, 0xC7, 0xFE, 0x03, 0xF3, 0xFF, 0x80, 0xFD, 0xFF, 0xE0, 0x3F,
  0xFE, 0x08, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0x60, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x8C, 0x00, 0x0F, 0xE1, 0xF0,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x82, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00,
  0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x07, 0xEF, 0xC0, 0xFF, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFF, 0x8F, 0x80, 0x7F, 0xFF, 0x1F, 0x80, 0x3F, 0xFE,
  0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xCF, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3E, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xCF, 0x80, 0x7F, 0x0F,
  0xC0, 0x3F, 0x3E, 0x01, 0xFC, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0x83, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x0F, 0xE1, 0xF0,
  0x3E, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x03,
  0xE3, 0xF8, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x3E,
  0x3F, 0x00, 0x1F, 0x9F, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x03, 0xE7,
  0xE0, 0x01, 0xFB, 0xE0, 0x0F, 0xBF, 0x80, 0x07, 0xDF, 0x80, 0x3E, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x81, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x02, 0x7F, 0xFC, 0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x60, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 17, 47, 17, 1, -46 },
  { 101, 20, 17, 26, 7, -46 },
  { 144, 40, 46, 41, 2, -46 },
  { 374, 32, 53, 35, 2, -49 },
  { 586, 45, 47, 52, 5, -46 },
  { 851, 40, 47, 44, 2, -46 },
  { 1086, 9, 17, 15, 7, -46 },
  { 1106, 22, 56, 19, 2, -46 },
  { 1260, 22, 56, 20, -5, -46 },
  { 1414, 30, 30, 35, 6, -49 },
  { 1527, 31, 31, 37, 4, -38 },
  { 1648, 14, 15, 17, -3, -7 },
  { 1675, 17, 6, 20, 1, -20 },
  { 1688, 9, 9, 17, 1, -8 },
  { 1699, 32, 46, 24, -3, -46 },
  { 1883, 31, 47, 35, 3, -46 },
  { 2066, 21, 46, 35, 8, -46 },
  { 2187, 34, 46, 35, 0, -46 },
  { 2383, 33, 47, 35, 1, -46 },
  { 2577, 34, 46, 35, 0, -46 },
  { 2773, 33, 47, 35, 2, -46 },
  { 2967, 31, 47, 35, 4, -46 },
  { 3150, 33, 46, 35, 4, -46 },
  { 3340, 32, 47, 35, 3, -46 },
  { 3528, 31, 47, 35, 3, -46 },
  { 3711, 14, 36, 17, 1, -35 },
  { 3774, 18, 43, 17, -3, -35 },
  { 3871, 31, 32, 37, 4, -39 },
  { 3995, 30, 17, 37, 4, -31 },
  { 4059, 31, 32, 37, 4, -39 },
  { 4183, 25, 47, 28, 5, -46 },
  { 4330, 50, 52, 54, 3, -46 },
  { 4655, 38, 46, 37, -4, -46 },
  { 4874, 36, 46, 39, 2, -46 },
  { 5081, 37, 47, 38, 4, -46 },
  { 5299, 39, 46, 43, 2, -46 },
  { 5524, 34, 46, 33, 2, -46 },
  { 5720, 34, 46, 32, 2, -46 },
  { 5916, 39, 47, 44, 4, -46 },
  { 6146, 42, 46, 44, 2, -46 },
  { 6388, 26, 46, 22, -1, -46 },
  { 6538, 29, 59, 19, -10, -46 },
  { 6752, 41, 46, 37, 2, -46 },
  { 6988, 25, 46, 31, 2, -46 },
  { 7132, 53, 46, 55, 2, -46 },
  { 7437, 45, 46, 46, 2, -46 },
  { 7696, 40, 47, 46, 4, -46 },
  { 7931, 35, 46, 37, 2, -46 },
  { 8133, 40, 57, 46, 4, -46 },
  { 8418, 35, 46, 38, 2, -46 },
  { 8620, 33, 47, 33, 1, -46 },
  { 8814, 32, 46, 33, 6, -46 },
  { 8998, 39, 47, 44, 5, -46 },
  { 9228, 36, 46, 36, 6, -46 },
  { 9435, 54, 46, 55, 7, -46 },
  { 9746, 43, 46, 35, -3, -46 },
  { 9994, 33, 46, 34, 6, -46 },
  { 10184, 38, 46, 34, -1, -46 },
  { 10403, 25, 56, 19, -1, -46 },
  { 10578, 13, 46, 24, 7, -46 },
  { 10653, 25, 56, 19, -5, -46 },
  { 10828, 32, 29, 36, 2, -46 },
  { 10944, 27, 4, 25, -6, 6 },
  { 10958, 12, 10, 19, 9, -49 },
  { 10973, 33, 36, 37, 3, -35 },
  { 11122, 32, 50, 37, 2, -49 },
  { 11322, 27, 36, 30, 3, -35 },
  { 11444, 36, 50, 37, 3, -49 },
  { 11669, 28, 36, 33, 3, -35 },
  { 11795, 36, 64, 21, -7, -49 },
  { 12083, 35, 50, 37, 1, -35 },
  { 12302, 32, 49, 38, 2, -49 },
  { 12498, 16, 48, 17, 2, -48 },
  { 12594, 26, 63, 17, -8, -48 },
  { 12799, 33, 49, 33, 2, -49 },
  { 13002, 17, 49, 17, 2, -49 },
  { 13107, 51, 35, 57, 2, -35 },
  { 13331, 33, 35, 38, 1, -35 },
  { 13476, 30, 36, 36, 3, -35 },
  { 13611, 36, 50, 37, -2, -35 },
  { 13836, 33, 50, 37, 3, -35 },
  { 14043, 26, 35, 26, 2, -35 },
  { 14157, 27, 36, 28, 0, -35 },
  { 14279, 22, 43, 23, 3, -42 },
  { 14398, 32, 36, 38, 4, -35 },
  { 14542, 31, 35, 31, 3, -35 },
  { 14678, 46, 35, 47, 4, -35 },
  { 14880, 37, 35, 32, -3, -35 },
  { 15042, 40, 50, 31, -6, -35 },
  { 15292, 30, 35, 29, -1, -35 },
  { 15424, 25, 56, 23, 1, -46 },
  { 15599, 5, 64, 35, 16, -49 },
  { 15639, 25, 56, 23, -3, -46 },
  { 15814, 31, 9, 37, 4, -27 },
};

const GFXfont NotoSans_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_MEDIUMITALIC64PT7B_H_
