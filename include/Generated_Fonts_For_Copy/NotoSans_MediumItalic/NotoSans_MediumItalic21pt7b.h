#ifndef _NOTOSANS_MEDIUMITALIC21PT7B_H_
#define _NOTOSANS_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC2, 0x00, 0x63, 0x8E,
  0x00, 0x66, 0xCD, 0x36, 0x6C, 0xC0, 0x06, 0x20, 0x33, 0x03, 0x18, 0x18,
  0x87, 0xFF, 0xBF, 0xFC, 0x62, 0x03, 0x30, 0x11, 0x87, 0xFF, 0xBF, 0xF8,
  0x66, 0x02, 0x30, 0x31, 0x01, 0x98, 0x00, 0x03, 0x00, 0x81, 0xFC, 0xFF,
  0x36, 0x19, 0x07, 0x40, 0xF0, 0x1F, 0x03, 0xE0, 0x98, 0x26, 0x8B, 0xBF,
  0xCF, 0xE0, 0x40, 0x10, 0x00, 0x38, 0x19, 0xB0, 0xCC, 0xC3, 0x33, 0x18,
  0x8C, 0xC2, 0x36, 0x08, 0x9B, 0xF6, 0xDB, 0xF6, 0xCC, 0x33, 0x30, 0xCC,
  0xC6, 0x23, 0x30, 0x8D, 0x83, 0x6E, 0x0F, 0x00, 0x0F, 0x80, 0xFE, 0x06,
  0x30, 0x31, 0x81, 0x9C, 0x0D, 0xC0, 0x78, 0x07, 0x80, 0x76, 0x3F, 0x39,
  0xB0, 0xF9, 0x83, 0xCC, 0x1C, 0x7F, 0xF1, 0xF9, 0xC0, 0x6D, 0x6C, 0x06,
  0x18, 0x61, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0xC0, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0x06, 0x01, 0x84,
  0x43, 0xF0, 0x3F, 0xC7, 0xF3, 0x41, 0x98, 0x66, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x3B, 0x98, 0xCC, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0xD8,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1B, 0x06, 0xE3, 0x1F, 0xC3, 0xC0,
  0x0E, 0x79, 0xF7, 0x69, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E,
  0x18, 0x00, 0x0F, 0xC3, 0xFC, 0x41, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xBF, 0xE0, 0x0F,
  0xC3, 0xFC, 0x41, 0x80, 0x30, 0x06, 0x01, 0x83, 0xE0, 0x78, 0x11, 0x80,
  0x18, 0x03, 0x00, 0x68, 0x1D, 0xFF, 0x1F, 0xC0, 0x00, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x6C, 0x19, 0x86, 0x31, 0xCE, 0x71, 0x8C, 0x33, 0xFF, 0xFF,
  0xF0, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xC7, 0xF3, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0xF0, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x83, 0xBF, 0xCF, 0xE0,
  0x07, 0xE1, 0xF8, 0x60, 0x18, 0x07, 0x00, 0xC4, 0x1F, 0xE3, 0x8C, 0xE1,
  0xDC, 0x3B, 0x06, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x7F, 0xEF, 0xFC,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x87, 0xF3, 0x0C, 0xC3, 0x30,
  0xCE, 0x71, 0xF0, 0xFC, 0x73, 0xB8, 0x6C, 0x1B, 0x06, 0xC1, 0xBF, 0xC7,
  0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xD8, 0x36, 0x1D, 0xCF, 0x3F,
  0xC2, 0x60, 0x18, 0x0C, 0x07, 0x3F, 0x8F, 0xC0, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x03, 0x39, 0xC0, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x1C, 0x63, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x38, 0x38, 0x38, 0x38, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x30, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x80, 0x38, 0x07, 0x80, 0x38, 0x03, 0x80, 0x30, 0x3C, 0x7C,
  0x78, 0x38, 0x08, 0x00, 0x7E, 0xFE, 0x87, 0x03, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0x60, 0x60, 0x00, 0xC0, 0xE0, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x1C,
  0x06, 0x30, 0x03, 0x21, 0xF3, 0x63, 0xF1, 0x46, 0x31, 0xCC, 0x31, 0xCC,
  0x23, 0xCC, 0x63, 0xCC, 0x66, 0xCF, 0xBE, 0xC7, 0x38, 0x60, 0x00, 0x30,
  0x10, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0xC0, 0x1E, 0x03, 0xE0, 0x36, 0x07,
  0x60, 0x66, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0xFE, 0x3F, 0xF3, 0x03, 0x60,
  0x36, 0x03, 0xC0, 0x30, 0x1F, 0xC1, 0xFE, 0x38, 0x63, 0x07, 0x30, 0x63,
  0x0E, 0x3F, 0xC7, 0xF8, 0x61, 0xC6, 0x0C, 0x60, 0xE6, 0x0C, 0xE1, 0xCF,
  0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x1C, 0x13, 0x80, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xFC,
  0x1F, 0xC0, 0x1F, 0x81, 0xFE, 0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x30,
  0x37, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66, 0x0E, 0xE1, 0xCF, 0xF8, 0xFE,
  0x00, 0x1F, 0xE3, 0xF8, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE3, 0xFC,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3,
  0xF8, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0xFC, 0x7F, 0x8C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0x02,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x3E, 0xE1, 0xF7, 0x03, 0xB8,
  0x18, 0xC0, 0xC7, 0x06, 0x1F, 0xF0, 0x7F, 0x00, 0x18, 0x18, 0xC0, 0xCE,
  0x06, 0x60, 0x33, 0x03, 0x98, 0x18, 0xFF, 0xCF, 0xFE, 0x60, 0x73, 0x03,
  0x18, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x73, 0x03, 0x00, 0x1F, 0x3E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x78, 0xF8,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x7C, 0x3C, 0x00, 0x18, 0x38,
  0xC3, 0x8E, 0x38, 0x63, 0x83, 0x38, 0x1B, 0x80, 0xF8, 0x0F, 0xC0, 0x76,
  0x03, 0x38, 0x18, 0xC0, 0xC7, 0x0E, 0x18, 0x60, 0xC3, 0x07, 0x00, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0xFF, 0xFF, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x03, 0xC6, 0x81, 0xE3, 0x41,
  0xB1, 0xB0, 0xD8, 0xD8, 0xDC, 0xCC, 0x6C, 0x66, 0x66, 0x33, 0x33, 0x19,
  0xB1, 0x9C, 0xD1, 0xCC, 0x78, 0xC6, 0x18, 0x63, 0x0C, 0x30, 0x1C, 0x0C,
  0x70, 0x33, 0xC0, 0xCF, 0x87, 0x36, 0x18, 0xD8, 0x63, 0x31, 0x98, 0xC6,
  0x63, 0x31, 0x86, 0xC6, 0x1B, 0x38, 0x7C, 0xC0, 0xF3, 0x03, 0x8C, 0x0E,
  0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x70, 0x19, 0x80, 0x76,
  0x01, 0xD8, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0x98, 0x1C, 0x70, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0xE3, 0x98, 0x33, 0x06, 0x60,
  0xCC, 0x3B, 0xFE, 0x7F, 0x8C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x70, 0x19, 0x80, 0x76,
  0x01, 0xD8, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0x98, 0x1C, 0x70, 0xE0,
  0xFF, 0x81, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F,
  0x83, 0xF8, 0xE3, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x33, 0xFC, 0x7F, 0x0C,
  0x61, 0x8C, 0x31, 0xCE, 0x19, 0x83, 0x30, 0x70, 0x0F, 0xE3, 0xFC, 0x60,
  0x9C, 0x03, 0x80, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x30, 0x06, 0x00,
  0xC8, 0x39, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x00,
  0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x33, 0x81, 0x98,
  0x0C, 0xC0, 0xE6, 0x07, 0x30, 0x31, 0x81, 0x8C, 0x18, 0x7F, 0xC1, 0xF8,
  0x00, 0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x0C, 0xE1, 0x8E, 0x18, 0x63, 0x06,
  0x30, 0x66, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x00,
  0xC0, 0xC0, 0xF0, 0x70, 0x6C, 0x1C, 0x1B, 0x0F, 0x0E, 0xC3, 0x43, 0x31,
  0x91, 0xCC, 0x64, 0x63, 0x19, 0x18, 0xEC, 0x6C, 0x1B, 0x1B, 0x07, 0x87,
  0x81, 0x61, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x06, 0x07, 0x00, 0x1C, 0x1C,
  0x30, 0x60, 0xC3, 0x01, 0x9C, 0x06, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x36, 0x01, 0xCC, 0x06, 0x30, 0x30, 0xE1, 0x81, 0x8E, 0x06,
  0x00, 0xC0, 0xFC, 0x39, 0x86, 0x31, 0xC6, 0x30, 0xCC, 0x0F, 0x81, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0x1F, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xF0, 0xCC, 0x66, 0x66, 0x66, 0x33, 0x33, 0x33, 0x30, 0x1F,
  0x1E, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0xF0, 0x0C, 0x03, 0x81, 0xE0, 0x68, 0x33, 0x0C,
  0x46, 0x19, 0x86, 0xC0, 0xC0, 0xFF, 0x80, 0xE6, 0x30, 0x04, 0x03, 0xEC,
  0xE7, 0x38, 0xE6, 0x0D, 0xC3, 0xB0, 0x66, 0x0C, 0xC3, 0x98, 0x73, 0xF6,
  0x3C, 0x80, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x31, 0x0D, 0xE3, 0x9D, 0xC3,
  0x70, 0xD8, 0x36, 0x0F, 0x87, 0xE1, 0xB8, 0xEF, 0xF2, 0x78, 0x06, 0x0F,
  0xCE, 0x4E, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x1F, 0x87, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x04, 0x61, 0xFE, 0x39, 0xC7, 0x1C,
  0x60, 0xCE, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x38, 0xFD, 0x87, 0x90,
  0x04, 0x0F, 0xCE, 0x6E, 0x36, 0x1F, 0x7B, 0xF9, 0x80, 0xC0, 0x70, 0x1F,
  0xC7, 0xC0, 0x01, 0xF0, 0x3E, 0x03, 0x00, 0x30, 0x07, 0x01, 0xFC, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0xFB, 0x1C, 0xE3, 0x8E, 0x30, 0x67, 0x0E, 0x60, 0xC6, 0x0C, 0x61, 0xC6,
  0x1C, 0x7E, 0xC3, 0xD8, 0x01, 0x80, 0x18, 0x83, 0x8F, 0xF0, 0x7E, 0x00,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x31, 0x0D, 0xF3, 0xDD, 0xC3, 0x70, 0xD8,
  0x36, 0x1F, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0x11, 0xC6, 0x00, 0x18,
  0xCE, 0x63, 0x19, 0xCC, 0x63, 0x18, 0x01, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x1F, 0x0F, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x11, 0x8E, 0x19, 0xC3, 0xB8, 0x37, 0x03, 0xE0, 0x3E, 0x07, 0x70,
  0x63, 0x06, 0x30, 0x61, 0x8E, 0x1C, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38, 0x01, 0x04, 0x37, 0x9F, 0x2D, 0xF3,
  0x70, 0xE3, 0x70, 0xC3, 0x61, 0xC3, 0x61, 0x83, 0xE1, 0x87, 0xC1, 0x86,
  0xC1, 0x86, 0xC3, 0x86, 0xC3, 0x06, 0x00, 0x83, 0x7C, 0xFB, 0x9C, 0x33,
  0x86, 0x60, 0xCC, 0x3B, 0x87, 0x70, 0xCC, 0x19, 0x83, 0x70, 0xE0, 0x1F,
  0x8E, 0x67, 0x0D, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x06, 0xE3, 0x9F, 0xC3,
  0xE0, 0x00, 0x40, 0xDE, 0x0A, 0x71, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x33,
  0x87, 0x38, 0x63, 0x8E, 0x3F, 0xC3, 0x78, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x00, 0x04, 0x03, 0xEC, 0xE7, 0x38, 0xE6, 0x0D, 0xC3, 0xB0,
  0x66, 0x0C, 0xC3, 0x98, 0x73, 0xF6, 0x3D, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x01, 0x37, 0x3F, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x04, 0x1F, 0xCC, 0x4E, 0x03, 0x01, 0xE0, 0x78, 0x0E,
  0x03, 0x03, 0xBF, 0x9F, 0x80, 0x18, 0x20, 0xC7, 0xF3, 0x0E, 0x18, 0x30,
  0x60, 0xC3, 0x86, 0x0F, 0x8F, 0x00, 0x30, 0xEE, 0x19, 0x83, 0x30, 0x66,
  0x0C, 0xC3, 0xB8, 0x66, 0x1C, 0xC3, 0x9F, 0xB1, 0xE4, 0x00, 0xC1, 0xF0,
  0x6C, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xC1, 0xB0, 0x78, 0x1E, 0x07, 0x00,
  0xC3, 0x87, 0x87, 0x1F, 0x1E, 0x36, 0x3C, 0xEC, 0xD9, 0x99, 0xB3, 0x16,
  0x6C, 0x2C, 0xD8, 0x50, 0xE0, 0xE1, 0xC1, 0x83, 0x00, 0x18, 0x71, 0xCE,
  0x0D, 0xC0, 0xD8, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xB0, 0x39, 0x87, 0x18,
  0xE1, 0xC0, 0x18, 0x38, 0xC1, 0x87, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60,
  0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x03, 0xE0, 0x1E, 0x00, 0x3F, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x7F, 0xBF, 0x80, 0x03, 0x83, 0x83, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0xF0, 0x70, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x78,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x1E, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x07, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x70, 0xE0, 0x78, 0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 6, 0, -15 },
  { 13, 7, 5, 9, 2, -15 },
  { 18, 13, 15, 14, 1, -15 },
  { 43, 10, 17, 12, 1, -16 },
  { 65, 14, 15, 17, 2, -15 },
  { 92, 13, 15, 14, 1, -15 },
  { 117, 3, 5, 5, 2, -15 },
  { 119, 7, 18, 6, 1, -15 },
  { 135, 8, 18, 6, -2, -15 },
  { 153, 10, 10, 12, 2, -16 },
  { 166, 10, 11, 12, 1, -13 },
  { 180, 5, 5, 6, -1, -2 },
  { 184, 6, 2, 7, 0, -7 },
  { 186, 3, 3, 6, 0, -3 },
  { 188, 11, 15, 8, -1, -15 },
  { 209, 10, 15, 12, 1, -15 },
  { 228, 7, 15, 12, 3, -15 },
  { 242, 11, 15, 12, 0, -15 },
  { 263, 11, 15, 12, 0, -15 },
  { 284, 11, 15, 12, 0, -15 },
  { 305, 10, 15, 12, 1, -15 },
  { 324, 11, 15, 12, 1, -15 },
  { 345, 11, 15, 12, 1, -15 },
  { 366, 10, 15, 12, 1, -15 },
  { 385, 10, 15, 12, 1, -15 },
  { 404, 5, 12, 6, 0, -12 },
  { 412, 6, 15, 6, -1, -12 },
  { 424, 10, 11, 12, 1, -13 },
  { 438, 10, 6, 12, 1, -10 },
  { 446, 10, 11, 12, 1, -13 },
  { 460, 8, 15, 9, 2, -15 },
  { 475, 16, 17, 18, 1, -15 },
  { 509, 12, 15, 12, -1, -15 },
  { 532, 12, 15, 13, 1, -15 },
  { 555, 12, 15, 13, 1, -15 },
  { 578, 12, 15, 14, 1, -15 },
  { 601, 11, 15, 11, 1, -15 },
  { 622, 11, 15, 10, 1, -15 },
  { 643, 13, 15, 14, 1, -15 },
  { 668, 13, 15, 14, 1, -15 },
  { 693, 8, 15, 7, 0, -15 },
  { 708, 9, 19, 6, -3, -15 },
  { 730, 13, 15, 12, 1, -15 },
  { 755, 8, 15, 10, 1, -15 },
  { 770, 17, 15, 18, 1, -15 },
  { 802, 14, 15, 15, 1, -15 },
  { 829, 14, 15, 15, 1, -15 },
  { 856, 11, 15, 12, 1, -15 },
  { 877, 14, 19, 15, 1, -15 },
  { 911, 11, 15, 12, 1, -15 },
  { 932, 11, 15, 11, 0, -15 },
  { 953, 10, 15, 11, 2, -15 },
  { 972, 13, 15, 14, 2, -15 },
  { 997, 12, 15, 12, 2, -15 },
  { 1020, 18, 15, 18, 2, -15 },
  { 1054, 14, 15, 12, -1, -15 },
  { 1081, 11, 15, 11, 2, -15 },
  { 1102, 12, 15, 11, 0, -15 },
  { 1125, 8, 18, 6, 0, -15 },
  { 1143, 4, 15, 8, 2, -15 },
  { 1151, 8, 18, 6, -1, -15 },
  { 1169, 10, 9, 12, 1, -15 },
  { 1181, 9, 1, 8, -2, 2 },
  { 1183, 4, 3, 6, 3, -16 },
  { 1185, 11, 12, 12, 1, -12 },
  { 1202, 10, 16, 12, 1, -16 },
  { 1222, 9, 12, 10, 1, -12 },
  { 1236, 12, 16, 12, 1, -16 },
  { 1260, 9, 12, 11, 1, -12 },
  { 1274, 12, 21, 7, -2, -16 },
  { 1306, 12, 17, 12, 0, -12 },
  { 1332, 10, 16, 12, 1, -16 },
  { 1352, 5, 16, 6, 1, -16 },
  { 1362, 9, 21, 6, -3, -16 },
  { 1386, 12, 16, 11, 0, -16 },
  { 1410, 6, 16, 6, 0, -16 },
  { 1422, 16, 12, 19, 1, -12 },
  { 1446, 11, 12, 12, 0, -12 },
  { 1463, 10, 11, 12, 1, -11 },
  { 1477, 12, 17, 12, -1, -12 },
  { 1503, 11, 17, 12, 1, -12 },
  { 1527, 8, 12, 9, 1, -12 },
  { 1539, 9, 12, 9, 0, -12 },
  { 1553, 7, 14, 7, 1, -14 },
  { 1566, 11, 11, 12, 1, -11 },
  { 1582, 10, 11, 10, 1, -11 },
  { 1596, 15, 11, 16, 1, -11 },
  { 1617, 12, 11, 10, -1, -11 },
  { 1634, 13, 16, 10, -2, -11 },
  { 1660, 9, 11, 9, 0, -11 },
  { 1673, 9, 18, 7, 0, -15 },
  { 1694, 2, 21, 12, 5, -16 },
  { 1700, 8, 18, 7, -1, -15 },
  { 1718, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_MEDIUMITALIC21PT7B_H_
