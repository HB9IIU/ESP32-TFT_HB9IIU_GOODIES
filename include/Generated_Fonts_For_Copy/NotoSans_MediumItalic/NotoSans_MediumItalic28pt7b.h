#ifndef _NOTOSANS_MEDIUMITALIC28PT7B_H_
#define _NOTOSANS_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73, 0xB9, 0xD8,
  0xDC, 0xEE, 0x76, 0x33, 0x18, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x18,
  0x03, 0x1C, 0x03, 0x8C, 0x01, 0x86, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x38, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0xF8, 0xF6, 0x03, 0x98,
  0x0E, 0x60, 0x3D, 0x80, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0D,
  0xC0, 0x67, 0x01, 0x9C, 0x86, 0x73, 0xFF, 0x8F, 0xFC, 0x07, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xE3, 0xF8, 0x18, 0x73, 0x83,
  0x86, 0x18, 0x70, 0x63, 0x86, 0x0E, 0x38, 0xC0, 0xE3, 0x9C, 0x0C, 0x33,
  0x80, 0xC3, 0x33, 0xEE, 0x76, 0x7E, 0xFE, 0xEE, 0x77, 0xDC, 0xC7, 0x01,
  0x9C, 0x70, 0x39, 0x87, 0x07, 0x18, 0x60, 0xE1, 0x86, 0x0C, 0x18, 0xE1,
  0xC1, 0x8C, 0x38, 0x1F, 0xC7, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0xF3, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x3B,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x3D, 0xE7, 0x0E, 0x70, 0xE7,
  0x38, 0x3D, 0xCE, 0x07, 0xE3, 0x80, 0xF0, 0xE0, 0x3C, 0x3C, 0x3F, 0x07,
  0xFE, 0xE0, 0xFE, 0x3C, 0x77, 0x6E, 0xEC, 0xC0, 0x01, 0xC0, 0xC0, 0x70,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0x03, 0x80, 0x18, 0x20, 0xC1, 0xC6, 0x0F,
  0xA0, 0x1F, 0xFC, 0x3F, 0xE3, 0xE1, 0x3B, 0x03, 0x9C, 0x1C, 0x60, 0x43,
  0x80, 0x10, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0xE7, 0x1C, 0x63, 0x8C, 0x00, 0xFF, 0xFF, 0xF8, 0x27,
  0xF7, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0x03, 0xF0, 0x3F, 0xE0, 0xE3, 0x87, 0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x81,
  0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x07, 0x9C, 0x1C, 0x70, 0xF1, 0xE7, 0x83, 0xFC, 0x07, 0xE0, 0x07,
  0x87, 0x8F, 0xCF, 0xEF, 0x76, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x03, 0xF8,
  0x1F, 0xF8, 0x7C, 0xF0, 0x60, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x03, 0xF8, 0x3F, 0xF8, 0x3C, 0xF8, 0x40, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x80, 0x79, 0xE1, 0xE3, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x3B, 0x80, 0xE6, 0x03, 0x9C, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xE1, 0xC1,
  0x87, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x80, 0xF3, 0x8F, 0x8F,
  0xFC, 0x3F, 0xE0, 0x01, 0xF8, 0x3F, 0xC3, 0xC2, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x70, 0xEF, 0xE7, 0xFF, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0, 0x7E, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x3F, 0xE0, 0xE3, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC3,
  0x9E, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x0E, 0x3C, 0x70, 0x73, 0x80, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x71, 0xC3, 0xC7, 0xFE, 0x0F, 0xF0, 0x07, 0xE0,
  0x3F, 0xC1, 0xE7, 0x8E, 0x0E, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F,
  0x70, 0x3D, 0xE1, 0xE3, 0xFF, 0x87, 0xEE, 0x0E, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE2, 0x1F, 0x0F, 0xF8, 0x3F, 0x80, 0x1E, 0x3C, 0x70,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x1E, 0x1C, 0x00, 0x0F,
  0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x8F, 0xF9, 0xC7, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x03, 0xC0, 0x0E, 0x1C, 0x00, 0x18, 0x60,
  0x20, 0x73, 0x87, 0xF8, 0xCC, 0x3D, 0xE3, 0x71, 0xC3, 0x0D, 0x8E, 0x0C,
  0x36, 0x38, 0x70, 0xF8, 0xC1, 0x87, 0xE3, 0x06, 0x1F, 0x8C, 0x38, 0x6E,
  0x31, 0xE3, 0x98, 0xFD, 0xFC, 0x61, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x40, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x06, 0xE0,
  0x07, 0x70, 0x03, 0x98, 0x03, 0x8C, 0x01, 0xC6, 0x01, 0xC3, 0x81, 0xE1,
  0xC0, 0xE0, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x70, 0x1C, 0x38, 0x0E, 0x38,
  0x03, 0x1C, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x70, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x38, 0x3C, 0x38, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x8E, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x70,
  0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xC1,
  0xE1, 0xC0, 0x70, 0xE0, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x79, 0xC0, 0x38,
  0xE0, 0x3C, 0x70, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xC3, 0xC0, 0x23,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x3F,
  0xB8, 0x1F, 0x9C, 0x1F, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xE0,
  0x38, 0x78, 0x1C, 0x3E, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0,
  0x1C, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0x0F, 0xF0, 0xFF, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x7F, 0x0F,
  0xF0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F,
  0xE0, 0xFC, 0x00, 0x0E, 0x03, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x30, 0x70,
  0x1C, 0x38, 0x07, 0x1E, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1C, 0x38, 0x07, 0x0E,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0x83, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1B, 0x87, 0x60, 0x77,
  0x0C, 0xC0, 0xCC, 0x39, 0x83, 0xB8, 0x73, 0x0E, 0x70, 0xE6, 0x1C, 0xE1,
  0xCE, 0x71, 0xC3, 0x1C, 0xE7, 0x0E, 0x3B, 0x8E, 0x1C, 0x76, 0x1C, 0x38,
  0xFC, 0x38, 0x70, 0xF0, 0x70, 0xC1, 0xE1, 0xC3, 0x83, 0x83, 0x87, 0x07,
  0x07, 0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x8F, 0xC0, 0x71,
  0xF8, 0x0C, 0x3B, 0x83, 0x87, 0x70, 0x70, 0xCE, 0x0E, 0x38, 0xE1, 0xC7,
  0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x39, 0xC3, 0x07, 0x38, 0xE0, 0xE7, 0x1C,
  0x0E, 0xC3, 0x81, 0xF8, 0x70, 0x1F, 0x0C, 0x03, 0xE3, 0x80, 0x78, 0x70,
  0x07, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0,
  0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1C,
  0x70, 0x1E, 0x3E, 0x7E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x38, 0x1E, 0x70, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x07, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0, 0x3B, 0xC0, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1C, 0x70, 0x1E, 0x3E,
  0x7E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70,
  0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x1C, 0x7F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xE0, 0x07, 0xF8, 0x3F, 0xF1, 0xE3,
  0x8F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x80,
  0xE3, 0x8F, 0x8F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x8E, 0x01,
  0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xF0, 0x38, 0x3E, 0x7C, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x03,
  0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE0, 0xC3, 0x81, 0x87, 0x03,
  0x1C, 0x07, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0E, 0xE0,
  0x78, 0x0E, 0xE0, 0x78, 0x1C, 0xE0, 0xF8, 0x1C, 0xE0, 0xD8, 0x38, 0xE1,
  0xDC, 0x38, 0xE1, 0xDC, 0x70, 0xE3, 0x9C, 0x70, 0xE3, 0x9C, 0x70, 0xE7,
  0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE6, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC,
  0x1D, 0x80, 0xFC, 0x1F, 0x80, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x38, 0x1E, 0x03, 0x83,
  0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xDE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xB8, 0x00, 0x79, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x0E, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x1F, 0x80, 0xEE, 0x07,
  0xB8, 0x1C, 0x70, 0xE1, 0xC7, 0x87, 0x1C, 0x0C, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xE0,
  0xF8, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0xE3, 0x8E, 0x18, 0x61, 0x87,
  0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x07, 0xE0,
  0xFC, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x3F, 0x07, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0xF0, 0x0C, 0xC0, 0x33, 0x81, 0x86, 0x06, 0x1C, 0x30, 0x30, 0xC0,
  0xC6, 0x03, 0xB8, 0x06, 0xE0, 0x1C, 0xFF, 0xF0, 0xF3, 0x8C, 0x30, 0x07,
  0xCE, 0x3F, 0xD8, 0x79, 0xF1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x87, 0x1F, 0x0F,
  0xEE, 0x0F, 0x9C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xDF, 0x06, 0xFE, 0x3E, 0x3C, 0xF0, 0x73, 0x81, 0xCE,
  0x07, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x3B, 0xC1, 0xCF,
  0x8F, 0x3F, 0xF8, 0xCF, 0xC0, 0x07, 0xF1, 0xFF, 0x1E, 0x23, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0xC3, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x07, 0xCC, 0x1F, 0xFC, 0x3C, 0x7C, 0x38, 0x3C,
  0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x78,
  0xE0, 0x70, 0xF0, 0xF0, 0x71, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x07, 0xE0,
  0xFF, 0x87, 0x1E, 0x70, 0x77, 0x03, 0xB8, 0x39, 0xFF, 0x9F, 0xF8, 0xF8,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x86, 0x1F, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC4, 0x03,
  0xF8, 0x0F, 0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xCE, 0x3F, 0xD8, 0xF9,
  0xF1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x87, 0x1F, 0x0F, 0xEE, 0x0F, 0x9C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC2, 0x07, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xDF, 0x86, 0xFE, 0x3F, 0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x78, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0x70, 0x0E, 0x1C, 0x38, 0x60, 0x00, 0x07, 0x0E, 0x38, 0x70, 0xE1,
  0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xC0,
  0xFC, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC3, 0xC6, 0x1E, 0x38, 0xF0, 0xE3, 0x83, 0x9C, 0x0E, 0xE0,
  0x77, 0x01, 0xFC, 0x07, 0xB8, 0x1C, 0xE0, 0x71, 0xC3, 0x87, 0x0E, 0x1E,
  0x38, 0x38, 0xE0, 0xF0, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x00, 0x19,
  0xF0, 0xF8, 0x6F, 0xE7, 0xF3, 0xE3, 0xB1, 0xCF, 0x07, 0x87, 0x3C, 0x1C,
  0x1C, 0xE0, 0xF0, 0x73, 0x83, 0x81, 0xDC, 0x0E, 0x07, 0x70, 0x38, 0x39,
  0xC0, 0xC0, 0xE7, 0x07, 0x03, 0xB8, 0x1C, 0x0E, 0xE0, 0x70, 0x3B, 0x81,
  0xC1, 0xCE, 0x0E, 0x07, 0x00, 0x19, 0xF8, 0xEF, 0xF3, 0xF3, 0xCF, 0x07,
  0x3C, 0x1C, 0xE0, 0x77, 0x83, 0xDC, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x00, 0x07, 0xE0, 0x7F, 0xC3,
  0xC7, 0x8E, 0x0E, 0x70, 0x3D, 0xC0, 0x77, 0x01, 0xF8, 0x0E, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0x9C, 0x1C, 0x79, 0xE0, 0xFF, 0x81, 0xF8, 0x00, 0x06,
  0x7C, 0x06, 0xFE, 0x0F, 0x8F, 0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1C, 0x3E,
  0x3C, 0x3F, 0xF8, 0x3B, 0xF0, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xCE, 0x3F, 0xD8, 0xF1,
  0xF1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x87, 0x1F, 0x0F, 0xEE, 0x0F, 0x9C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x19, 0xE3, 0x7C, 0xFE, 0x9F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0xE1,
  0xFF, 0x3C, 0x23, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1C, 0x01, 0xE0, 0x1C, 0xC3, 0xCF, 0xFC, 0x7F, 0x00, 0x0E, 0x03, 0x01,
  0xC1, 0xFF, 0xFF, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC8, 0x7E, 0x0F, 0x80, 0x38, 0x1D, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE3, 0xE3, 0xFB, 0x87, 0xCE, 0x00, 0xE0,
  0x3D, 0x80, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1C,
  0x70, 0x73, 0x81, 0xCE, 0x03, 0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0xC0, 0xE0, 0x7C, 0x1E, 0x0E, 0xE1, 0xE0, 0xEE, 0x3E, 0x1C,
  0xE3, 0x61, 0xCE, 0x76, 0x38, 0xE7, 0x73, 0x8E, 0x67, 0x30, 0xEE, 0x77,
  0x0E, 0xC7, 0x60, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x07,
  0xC0, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x3C, 0x07, 0x38,
  0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x70, 0xF0, 0x38, 0x1C, 0x07,
  0x86, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x06, 0x70, 0x03, 0x38, 0x01, 0xB8, 0x00, 0xDC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xE0,
  0x7C, 0x0F, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xF0, 0x1C, 0x0F, 0x83, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x3E, 0x07, 0x80, 0x78,
  0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 20, 8, 0, -20 },
  { 21, 9, 7, 11, 3, -20 },
  { 29, 17, 20, 18, 1, -20 },
  { 72, 14, 23, 15, 1, -21 },
  { 113, 20, 20, 23, 2, -20 },
  { 163, 18, 20, 19, 1, -20 },
  { 208, 4, 7, 6, 3, -20 },
  { 212, 10, 24, 9, 1, -20 },
  { 242, 9, 24, 9, -2, -20 },
  { 269, 13, 13, 15, 3, -21 },
  { 291, 13, 14, 16, 2, -17 },
  { 314, 6, 7, 7, -1, -3 },
  { 320, 7, 3, 9, 1, -9 },
  { 323, 4, 4, 7, 0, -4 },
  { 325, 14, 20, 11, -1, -20 },
  { 360, 14, 20, 15, 1, -20 },
  { 395, 9, 20, 15, 4, -20 },
  { 418, 15, 20, 15, 0, -20 },
  { 456, 15, 20, 15, 0, -20 },
  { 494, 15, 20, 15, 0, -20 },
  { 532, 14, 20, 15, 1, -20 },
  { 567, 13, 20, 15, 2, -20 },
  { 600, 14, 20, 15, 2, -20 },
  { 635, 14, 20, 15, 1, -20 },
  { 670, 14, 20, 15, 1, -20 },
  { 705, 7, 15, 7, 0, -15 },
  { 719, 8, 19, 7, -1, -15 },
  { 738, 13, 14, 16, 2, -17 },
  { 761, 13, 8, 16, 2, -14 },
  { 774, 13, 14, 16, 2, -17 },
  { 797, 11, 20, 12, 2, -20 },
  { 825, 22, 23, 24, 1, -20 },
  { 889, 17, 20, 16, -2, -20 },
  { 932, 16, 20, 17, 1, -20 },
  { 972, 16, 20, 17, 2, -20 },
  { 1012, 17, 20, 19, 1, -20 },
  { 1055, 15, 20, 15, 1, -20 },
  { 1093, 15, 20, 14, 1, -20 },
  { 1131, 17, 20, 19, 2, -20 },
  { 1174, 18, 20, 19, 1, -20 },
  { 1219, 12, 20, 10, -1, -20 },
  { 1249, 12, 25, 8, -4, -20 },
  { 1287, 18, 20, 16, 1, -20 },
  { 1332, 11, 20, 14, 1, -20 },
  { 1360, 23, 20, 24, 1, -20 },
  { 1418, 19, 20, 20, 1, -20 },
  { 1466, 17, 20, 20, 2, -20 },
  { 1509, 15, 20, 16, 1, -20 },
  { 1547, 17, 25, 20, 2, -20 },
  { 1601, 15, 20, 16, 1, -20 },
  { 1639, 14, 20, 14, 1, -20 },
  { 1674, 15, 20, 14, 2, -20 },
  { 1712, 17, 20, 19, 2, -20 },
  { 1755, 15, 20, 16, 3, -20 },
  { 1793, 24, 20, 24, 3, -20 },
  { 1853, 20, 20, 15, -2, -20 },
  { 1903, 14, 20, 15, 3, -20 },
  { 1938, 16, 20, 15, 0, -20 },
  { 1978, 11, 24, 8, 0, -20 },
  { 2011, 6, 20, 11, 3, -20 },
  { 2026, 11, 24, 8, -2, -20 },
  { 2059, 14, 13, 16, 1, -20 },
  { 2082, 12, 1, 11, -3, 3 },
  { 2084, 5, 4, 8, 4, -21 },
  { 2087, 15, 15, 16, 1, -15 },
  { 2116, 14, 21, 16, 1, -21 },
  { 2153, 12, 15, 13, 1, -15 },
  { 2176, 16, 21, 16, 1, -21 },
  { 2218, 13, 15, 14, 1, -15 },
  { 2243, 16, 28, 9, -3, -21 },
  { 2299, 15, 22, 16, 1, -15 },
  { 2341, 14, 21, 16, 1, -21 },
  { 2378, 7, 21, 8, 1, -21 },
  { 2397, 12, 28, 8, -4, -21 },
  { 2439, 14, 21, 14, 1, -21 },
  { 2476, 7, 21, 8, 1, -21 },
  { 2495, 22, 15, 25, 1, -15 },
  { 2537, 14, 15, 16, 1, -15 },
  { 2564, 14, 15, 16, 1, -15 },
  { 2591, 16, 22, 16, -1, -15 },
  { 2635, 15, 22, 16, 1, -15 },
  { 2677, 11, 15, 11, 1, -15 },
  { 2698, 12, 15, 12, 0, -15 },
  { 2721, 10, 18, 10, 1, -18 },
  { 2744, 14, 15, 16, 2, -15 },
  { 2771, 14, 15, 13, 1, -15 },
  { 2798, 20, 15, 21, 2, -15 },
  { 2836, 16, 15, 14, -1, -15 },
  { 2866, 17, 22, 14, -2, -15 },
  { 2913, 13, 15, 13, 0, -15 },
  { 2938, 11, 24, 10, 0, -20 },
  { 2971, 2, 28, 15, 7, -21 },
  { 2978, 11, 24, 10, -1, -20 },
  { 3011, 13, 4, 16, 2, -12 },
};

const GFXfont NotoSans_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_MEDIUMITALIC28PT7B_H_
