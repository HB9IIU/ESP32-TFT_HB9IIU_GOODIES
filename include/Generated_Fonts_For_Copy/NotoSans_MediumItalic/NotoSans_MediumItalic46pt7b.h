#ifndef _NOTOSANS_MEDIUMITALIC46PT7B_H_
#define _NOTOSANS_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x02, 0x00, 0x7C, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xC3, 0xE7,
  0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xE3, 0x83,
  0xC7, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xE7, 0x1C, 0x0F, 0x8E, 0x08, 0x3E, 0x1C, 0x00, 0x7C,
  0x70, 0x00, 0xF8, 0xE0, 0x01, 0xF1, 0xC0, 0x01, 0xF3, 0x80, 0x03, 0xF7,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0x7E, 0x00, 0x0E, 0x3E, 0x00, 0x1C, 0x7C,
  0x00, 0x38, 0xF8, 0x00, 0xE1, 0xF0, 0x01, 0xC3, 0xE6, 0x03, 0x8F, 0x8F,
  0x87, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xFE, 0x00,
  0x1E, 0x03, 0xFF, 0x00, 0x1E, 0x03, 0xE7, 0xC0, 0x1E, 0x03, 0xE1, 0xE0,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x87, 0x80, 0x1E, 0x07, 0x87, 0x80, 0x0F, 0x03, 0xC7, 0xC0, 0x07, 0x81,
  0xE3, 0xC7, 0xE3, 0xC1, 0xE3, 0xCF, 0xF8, 0xF0, 0xF3, 0xCF, 0xFE, 0x79,
  0xF3, 0xE7, 0xDF, 0x3F, 0xF9, 0xE7, 0x87, 0x8F, 0xF9, 0xE7, 0xC1, 0xE3,
  0xF1, 0xE3, 0xC0, 0xF0, 0x01, 0xF1, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x78,
  0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0xF8, 0x3C, 0x0F,
  0x00, 0x78, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x01, 0xF3, 0xE0, 0x3C, 0x00, 0x7F,
  0xE0, 0x3C, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x07, 0xC7, 0xF7, 0xE0, 0x3E, 0x7E, 0x1F, 0x83, 0xE3, 0xE0,
  0x7C, 0x1F, 0x3E, 0x01, 0xF1, 0xF1, 0xF0, 0x0F, 0xDF, 0x0F, 0x00, 0x3F,
  0xF8, 0xF8, 0x00, 0xFF, 0x87, 0xC0, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0x80,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xBF, 0x03, 0xFF, 0xF0, 0xF8, 0x07, 0xFE, 0x07, 0xE0, 0x7D, 0xF7,
  0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCE, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x30, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0xCE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x87, 0x83,
  0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xE7, 0x80, 0x7E, 0x3C, 0x03, 0xE0, 0xF0,
  0x0E, 0x07, 0x80, 0x30, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x00,
  0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0x3B, 0xFF, 0xFF, 0xFF, 0xE6, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x1E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0x7F,
  0x3C, 0x78, 0xF8, 0xE1, 0xF0, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xF0, 0x7F, 0x01, 0xC0, 0x1F, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3C, 0x07, 0xE0, 0x60, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC4, 0x00, 0x1F, 0x8E,
  0x00, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x85, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x80, 0x03, 0xF0, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x1E,
  0x01, 0xF3, 0xFE, 0x07, 0xDF, 0xFC, 0x1E, 0xFF, 0xF8, 0xFF, 0x87, 0xF3,
  0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0xF8, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0xF3, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x7F, 0x3F, 0x07, 0xFC, 0x7F, 0xFD, 0xE1, 0xFF, 0xEF, 0x81, 0xFF,
  0x3E, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x80,
  0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x18, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0x81, 0xF9, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x03, 0xF0, 0x1F, 0x1E, 0x01, 0xFF, 0xE0, 0xF1,
  0xE0, 0x3F, 0xFE, 0x0F, 0x3C, 0x0F, 0xE3, 0xE0, 0xF3, 0xC0, 0xF8, 0x3C,
  0x0F, 0x78, 0x1E, 0x03, 0xC0, 0xF7, 0x83, 0xE0, 0x3C, 0x0F, 0x78, 0x3C,
  0x03, 0xC0, 0xF7, 0x83, 0xC0, 0x78, 0x0F, 0x70, 0x78, 0x07, 0x80, 0xFF,
  0x07, 0x80, 0x78, 0x1E, 0xF0, 0x78, 0x0F, 0x81, 0xEF, 0x07, 0x80, 0xF0,
  0x1E, 0xF0, 0x78, 0x1F, 0x03, 0xCF, 0x07, 0x81, 0xF0, 0x7C, 0x70, 0x7C,
  0x7F, 0x8F, 0x87, 0x83, 0xFF, 0x7F, 0xF0, 0x78, 0x3F, 0xE3, 0xFE, 0x07,
  0x80, 0xFC, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xC0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC1, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3E, 0x0F, 0xF8, 0x1E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x3F,
  0x03, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0x81, 0xFC, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3E,
  0x0F, 0xF8, 0x07, 0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xE1, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x03,
  0xC0, 0x7F, 0x80, 0x04, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xF8, 0x03,
  0xFF, 0x8F, 0x80, 0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x3E,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x43, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x01,
  0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3D, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x07, 0xFE, 0x07, 0xBC, 0x00,
  0x3D, 0xF0, 0x3D, 0xE0, 0x03, 0xEF, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x1F,
  0x7C, 0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x0F, 0x3E, 0x07, 0x8F, 0x00, 0xF1,
  0xF0, 0x3C, 0x78, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x1F, 0x1E,
  0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xF0,
  0x3C, 0x3C, 0x1E, 0x0F, 0x03, 0xE1, 0xE1, 0xF0, 0xF8, 0x1F, 0x07, 0x8F,
  0x07, 0xC0, 0xF0, 0x3C, 0xF8, 0x3E, 0x07, 0x81, 0xE7, 0x81, 0xF0, 0x7C,
  0x0F, 0x78, 0x0F, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1F, 0x03, 0xFC, 0x07,
  0xC0, 0xF0, 0x1F, 0xE0, 0x3E, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x7C, 0x07,
  0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xF0, 0x00,
  0x3C, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0xC0, 0x03,
  0xE0, 0xFF, 0x80, 0x07, 0x81, 0xFF, 0x00, 0x1F, 0x03, 0xDF, 0x00, 0x3E,
  0x07, 0xBE, 0x00, 0x7C, 0x0F, 0x3C, 0x00, 0xF0, 0x3E, 0x7C, 0x01, 0xE0,
  0x7C, 0xF8, 0x07, 0xC0, 0xF0, 0xF0, 0x0F, 0x81, 0xE1, 0xF0, 0x1F, 0x03,
  0xC3, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0x83, 0xE0, 0x78, 0x0F, 0x87, 0xC0, 0xF0, 0x1F, 0x0F, 0x03, 0xE0,
  0x1E, 0x1E, 0x07, 0xC0, 0x3E, 0x7C, 0x0F, 0x00, 0x7C, 0xF8, 0x1E, 0x00,
  0x79, 0xF0, 0x7C, 0x00, 0xFB, 0xC0, 0xF8, 0x01, 0xF7, 0x81, 0xF0, 0x01,
  0xFF, 0x03, 0xC0, 0x03, 0xFE, 0x07, 0x80, 0x07, 0xF8, 0x1F, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3E, 0x1F, 0xF0, 0x1E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3E, 0x0F, 0xF0, 0x1E, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x03,
  0xF8, 0x3E, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x03,
  0xC0, 0xF8, 0x00, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x84, 0x00, 0x3F, 0x0E, 0x00, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x79,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x7F, 0x80,
  0x1F, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0xF8,
  0x07, 0xBC, 0x03, 0xE1, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0xF0,
  0x1F, 0x07, 0xC0, 0x79, 0xE0, 0x3E, 0x0F, 0x81, 0xF3, 0xC0, 0x78, 0x1F,
  0x03, 0xC7, 0x81, 0xF0, 0x3E, 0x0F, 0x8F, 0x03, 0xE0, 0x7C, 0x1E, 0x1E,
  0x0F, 0x80, 0xF8, 0x7C, 0x3C, 0x1F, 0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x03,
  0xE3, 0xE0, 0xF0, 0xF8, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x0F, 0x8F, 0x03,
  0xE7, 0xC0, 0x0F, 0x3C, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x07, 0xBE, 0x00,
  0x3D, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3C, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0x3C, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x1E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x20, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x00, 0xFE, 0x0F, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0x9E, 0x07,
  0xFF, 0xDE, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0x7C, 0x1F, 0xE0, 0x7F, 0xFD, 0xE0, 0x7F, 0xF9, 0xE0, 0x3F,
  0xF1, 0xE0, 0x1F, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xBF, 0xFE, 0x0F,
  0xF8, 0x7E, 0x0F, 0xE0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x03, 0xF0, 0x7B, 0xFF, 0xF0, 0x7B, 0xFF, 0xE0, 0xF1, 0xFF, 0x80, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xC0, 0x41, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xE1, 0xF0, 0x07, 0xFE, 0x78, 0x07, 0xFF, 0x9E, 0x03,
  0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0xFE, 0x01, 0xFF, 0xF7,
  0x80, 0x7F, 0xF9, 0xE0, 0x0F, 0xFC, 0x78, 0x01, 0xFE, 0x1C, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC1, 0xF1,
  0xF8, 0x0F, 0x3F, 0x00, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x7E,
  0x7C, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0x87, 0xFC, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0x80,
  0x7F, 0xE7, 0x80, 0xFF, 0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0x7E, 0x0F, 0xF0,
  0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xE0,
  0xFF, 0x01, 0xFF, 0xF7, 0x80, 0xFF, 0xF7, 0xC0, 0x3F, 0xF3, 0xE0, 0x0F,
  0xF1, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x3F, 0x01, 0xC0, 0x3F, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x3E, 0x7F, 0xE0,
  0x7D, 0xFF, 0xE0, 0xF7, 0xFF, 0xC3, 0xFE, 0x0F, 0x87, 0xF8, 0x1F, 0x0F,
  0xE0, 0x1E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x83,
  0xF0, 0x0F, 0xC0, 0x3C, 0x7F, 0xC1, 0xFF, 0x81, 0xE7, 0xFF, 0x1F, 0xFC,
  0x0F, 0x7F, 0xF9, 0xFF, 0xF0, 0x7F, 0x87, 0xDE, 0x0F, 0x87, 0xF0, 0x1F,
  0xE0, 0x7C, 0x3F, 0x80, 0xFE, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x83, 0xF8, 0x07, 0x8F, 0xFC,
  0x07, 0x9F, 0xFE, 0x07, 0xBF, 0xFE, 0x0F, 0xF8, 0x3E, 0x0F, 0xF0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E,
  0x03, 0xE3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x78, 0xFF,
  0x80, 0x1E, 0x7F, 0xF0, 0x07, 0xBF, 0xFE, 0x01, 0xFE, 0x1F, 0x80, 0xFE,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xBF, 0xFF, 0x01, 0xEF, 0xFF, 0x80, 0xF9, 0xFF, 0xC0,
  0x3E, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0x01, 0xFF, 0x9E, 0x07, 0xFF, 0xDE,
  0x0F, 0xFF, 0xDE, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0x7C, 0x1F, 0xE0, 0x7F, 0xFD, 0xE0, 0x7F, 0xFB, 0xE0,
  0x3F, 0xF3, 0xE0, 0x1F, 0xE3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0x87, 0xE0, 0xF1, 0xFC, 0x1E, 0x7F, 0x83, 0xDF,
  0xE0, 0xFF, 0xC4, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0x80, 0xC1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0xC0, 0x1F, 0x8F, 0xCF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0xC3, 0xC0, 0x3F,
  0x87, 0xC0, 0x7F, 0x0F, 0x83, 0xFC, 0x1F, 0xFF, 0x78, 0x3F, 0xFC, 0xF0,
  0x3F, 0xF1, 0xE0, 0x3F, 0xC3, 0xC0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7,
  0x80, 0x0F, 0x9E, 0x00, 0x7E, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xBC,
  0x03, 0xF8, 0x07, 0xDE, 0x01, 0xFC, 0x03, 0xEF, 0x00, 0xFE, 0x03, 0xE7,
  0x80, 0xFF, 0x01, 0xF3, 0xC0, 0x7F, 0x81, 0xF1, 0xE0, 0x7B, 0xC0, 0xF8,
  0xF0, 0x3D, 0xE0, 0xF8, 0x7C, 0x3C, 0xF0, 0x7C, 0x3E, 0x1E, 0x78, 0x7C,
  0x1F, 0x1E, 0x3C, 0x3E, 0x0F, 0x8F, 0x1E, 0x1E, 0x07, 0xCF, 0x8F, 0x1F,
  0x03, 0xE7, 0x87, 0x8F, 0x01, 0xF3, 0xC1, 0xCF, 0x80, 0xFB, 0xC0, 0xE7,
  0x80, 0x7D, 0xE0, 0x73, 0xC0, 0x3F, 0xE0, 0x3B, 0xE0, 0x1E, 0xF0, 0x1D,
  0xE0, 0x07, 0x70, 0x0E, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC0, 0x3F, 0xFA, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 34, 12, 1, -33 },
  { 52, 15, 12, 19, 5, -33 },
  { 75, 29, 33, 30, 1, -33 },
  { 195, 23, 38, 25, 1, -35 },
  { 305, 33, 33, 38, 3, -33 },
  { 442, 29, 33, 31, 1, -33 },
  { 562, 6, 12, 11, 5, -33 },
  { 571, 15, 40, 14, 2, -33 },
  { 646, 15, 40, 14, -3, -33 },
  { 721, 21, 21, 25, 5, -35 },
  { 777, 22, 22, 26, 3, -27 },
  { 838, 10, 11, 12, -2, -5 },
  { 852, 12, 4, 15, 1, -14 },
  { 858, 6, 7, 12, 1, -6 },
  { 864, 23, 33, 17, -2, -33 },
  { 959, 23, 33, 25, 2, -33 },
  { 1054, 15, 33, 25, 6, -33 },
  { 1116, 24, 33, 25, 0, -33 },
  { 1215, 23, 33, 25, 1, -33 },
  { 1310, 25, 33, 25, 0, -33 },
  { 1414, 24, 33, 25, 1, -33 },
  { 1513, 22, 33, 25, 3, -33 },
  { 1604, 23, 33, 25, 3, -33 },
  { 1699, 23, 33, 25, 2, -33 },
  { 1794, 22, 33, 25, 2, -33 },
  { 1885, 10, 26, 12, 1, -25 },
  { 1918, 13, 31, 12, -2, -25 },
  { 1969, 22, 23, 26, 3, -28 },
  { 2033, 22, 13, 26, 3, -23 },
  { 2069, 22, 23, 26, 3, -28 },
  { 2133, 17, 34, 20, 4, -33 },
  { 2206, 36, 37, 39, 2, -33 },
  { 2373, 27, 33, 27, -3, -33 },
  { 2485, 25, 33, 28, 2, -33 },
  { 2589, 26, 33, 27, 3, -33 },
  { 2697, 27, 33, 31, 2, -33 },
  { 2809, 24, 33, 24, 2, -33 },
  { 2908, 24, 33, 23, 2, -33 },
  { 3007, 28, 33, 31, 3, -33 },
  { 3123, 30, 33, 32, 2, -33 },
  { 3247, 19, 33, 16, -1, -33 },
  { 3326, 21, 42, 13, -7, -33 },
  { 3437, 29, 33, 27, 2, -33 },
  { 3557, 18, 33, 23, 2, -33 },
  { 3632, 37, 33, 39, 2, -33 },
  { 3785, 31, 33, 33, 2, -33 },
  { 3913, 29, 33, 33, 3, -33 },
  { 4033, 25, 33, 27, 2, -33 },
  { 4137, 29, 41, 33, 3, -33 },
  { 4286, 25, 33, 27, 2, -33 },
  { 4390, 23, 33, 24, 1, -33 },
  { 4485, 23, 33, 23, 4, -33 },
  { 4580, 29, 33, 31, 3, -33 },
  { 4700, 26, 33, 26, 4, -33 },
  { 4808, 39, 33, 40, 5, -33 },
  { 4969, 31, 33, 25, -2, -33 },
  { 5097, 24, 33, 24, 4, -33 },
  { 5196, 28, 33, 24, -1, -33 },
  { 5312, 18, 40, 14, -1, -33 },
  { 5402, 9, 33, 17, 5, -33 },
  { 5440, 18, 40, 14, -3, -33 },
  { 5530, 23, 21, 26, 1, -33 },
  { 5591, 19, 3, 18, -4, 4 },
  { 5599, 8, 7, 13, 7, -35 },
  { 5606, 24, 25, 26, 2, -25 },
  { 5681, 24, 35, 27, 1, -35 },
  { 5786, 20, 25, 21, 2, -25 },
  { 5849, 26, 35, 27, 2, -35 },
  { 5963, 20, 25, 24, 2, -25 },
  { 6026, 26, 46, 15, -5, -35 },
  { 6176, 25, 36, 27, 1, -25 },
  { 6289, 23, 35, 27, 1, -35 },
  { 6390, 12, 34, 12, 1, -34 },
  { 6441, 19, 45, 12, -6, -34 },
  { 6548, 24, 35, 24, 1, -35 },
  { 6653, 12, 35, 12, 1, -35 },
  { 6706, 37, 25, 41, 1, -25 },
  { 6822, 24, 25, 27, 1, -25 },
  { 6897, 22, 25, 26, 2, -25 },
  { 6966, 26, 36, 27, -1, -25 },
  { 7083, 24, 36, 27, 2, -25 },
  { 7191, 19, 25, 19, 1, -25 },
  { 7251, 20, 25, 20, 0, -25 },
  { 7314, 16, 30, 16, 2, -30 },
  { 7374, 23, 25, 27, 3, -25 },
  { 7446, 22, 25, 22, 2, -25 },
  { 7515, 33, 25, 34, 3, -25 },
  { 7619, 26, 25, 23, -2, -25 },
  { 7701, 28, 36, 22, -4, -25 },
  { 7827, 22, 25, 21, -1, -25 },
  { 7896, 19, 40, 16, 0, -33 },
  { 7991, 4, 46, 25, 11, -35 },
  { 8014, 18, 40, 16, -2, -33 },
  { 8104, 22, 6, 26, 3, -19 },
};

const GFXfont NotoSans_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_MEDIUMITALIC46PT7B_H_
