#ifndef _NOTOSANS_MEDIUMITALIC65PT7B_H_
#define _NOTOSANS_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE7, 0xF0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0,
  0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xC7, 0x87, 0xC0, 0x3F, 0xC3, 0xC0,
  0x40, 0x1F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x07, 0xF0, 0x78, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x01, 0xFC, 0x3E,
  0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0xFF, 0x80, 0x00,
  0x0F, 0x1F, 0xE0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x07, 0xC3, 0xF8, 0x00,
  0x03, 0xC1, 0xFC, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x00, 0xF0, 0x7F, 0x00,
  0x00, 0xF8, 0x3F, 0x84, 0x00, 0x7C, 0x3F, 0x83, 0x80, 0x3C, 0x3F, 0xC1,
  0xF8, 0x1E, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x20, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC3,
  0xF0, 0xFF, 0x8F, 0x80, 0xFC, 0x3F, 0x1F, 0xFE, 0x7E, 0x07, 0xE3, 0xF1,
  0xFF, 0xFB, 0xF0, 0x7E, 0x1F, 0x1F, 0xFF, 0xDF, 0x87, 0xF1, 0xF9, 0xFF,
  0xFF, 0x7F, 0xFF, 0x1F, 0x8F, 0xC1, 0xFB, 0xFF, 0xF1, 0xF8, 0xFC, 0x0F,
  0xCF, 0xFF, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0xF0, 0xFC, 0x7E, 0x01, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x00,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0x83, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFE,
  0x1F, 0xE0, 0x0F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0x80,
  0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x00, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF9,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x9E,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xBF,
  0xF8, 0x01, 0xFF, 0x80, 0x30, 0x07, 0xEF, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xF0, 0x7C, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x38, 0x03, 0xF0, 0x00, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0xC0, 0x04, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xF7, 0xF3, 0xFF, 0x9F, 0xC7, 0xFC, 0x7E, 0x0F, 0xC3,
  0xF8, 0x3C, 0x0F, 0xE0, 0x60, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x38, 0x00,
  0x3F, 0xC0, 0x04, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE1,
  0x80, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x82,
  0x00, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x87, 0xFE, 0x00, 0x3F, 0x9F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F,
  0xC7, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0,
  0x1F, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x03,
  0xFE, 0x01, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFE,
  0x38, 0x00, 0xFF, 0x10, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xF0,
  0x0F, 0x83, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x7E, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0xF0,
  0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0xFC, 0x07,
  0xE0, 0x03, 0xE0, 0x0F, 0xDF, 0x80, 0xFC, 0x00, 0x7C, 0x01, 0xFB, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xCF,
  0x80, 0xFC, 0x00, 0x7C, 0x00, 0xFB, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x3F,
  0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0xFC, 0x00, 0x7E, 0x00,
  0xF9, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xC7, 0xE0, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x3F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x0F, 0xFC, 0x1F, 0xC1, 0xF0, 0x1F, 0xE7,
  0xEF, 0xCF, 0xF0, 0x3F, 0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xE0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x00, 0x0C, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x38, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE,
  0x3F, 0x80, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00,
  0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xFF,
  0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0C,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x1F, 0x8F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xF9, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3E, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x1C, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC1, 0x80, 0x00, 0x3F, 0xC0, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x17, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF7,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0x8F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x7C, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFC,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0xE3, 0xF0,
  0x1F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC,
  0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0x1F, 0xC0,
  0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x0F, 0xDF, 0x80, 0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x0F,
  0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0xC1, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x18, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xF0, 0x03, 0xF8,
  0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0x80, 0x7E,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x1F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xE7, 0xFF,
  0xFE, 0x03, 0xF1, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0xFC, 0x00, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xC0, 0x7F, 0xC0, 0x04, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x60, 0x3F, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0x80, 0x03, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF,
  0xFB, 0xF0, 0x03, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0x7E, 0x00, 0x7F,
  0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0xFF, 0xC7, 0xC0,
  0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x8F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x3F,
  0xC0, 0x01, 0x80, 0xFF, 0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0xFE, 0x1F,
  0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF,
  0xDF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x07,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x3F, 0x7E, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0xF3, 0xF8, 0x00,
  0xFF, 0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x00, 0x1F, 0xE0, 0x0E,
  0x00, 0x07, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x07, 0xF0, 0x7F,
  0xE0, 0x03, 0xF0, 0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xFE, 0x01, 0xFC, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0xE0, 0x3F, 0xF8,
  0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x10, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x1F, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x03, 0xF7, 0xC1,
  0xFE, 0x7E, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xEF, 0x80, 0xFF, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0x0F, 0xC3, 0xFF,
  0xE0, 0x07, 0xE3, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x7E, 0xFF,
  0xFF, 0xE0, 0x1F, 0xBF, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xC1, 0xFF, 0xE0, 0x00,
  0x3E, 0x1F, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xFE, 0x00, 0x1F, 0xBF, 0xFF,
  0xF0, 0x00, 0xFD, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0xFD, 0xFF, 0xFF,
  0xC0, 0x0F, 0xEF, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0x03, 0xF8,
  0xFF, 0xF8, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xFF, 0x87, 0xE0, 0x1F,
  0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07,
  0xFC, 0x1F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0x07, 0xDF, 0x80, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF,
  0xCF, 0xE0, 0x0F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xC7, 0xF0, 0x00, 0xFF,
  0x83, 0xF8, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0x87, 0xFC, 0x0F, 0xC7, 0xFF, 0x03, 0xF1,
  0xFF, 0xC0, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xC0, 0x7F, 0x00, 0x0C, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x80, 0x00, 0x7F, 0x0E,
  0x00, 0x0F, 0xF0, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x04,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0x07, 0xEF, 0xC0, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x8F,
  0xC0, 0x7F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0x80, 0x1F, 0xF8, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFB, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xCF, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x9F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3E, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x7C, 0x07, 0xF0, 0x3F,
  0x81, 0xF0, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xE1, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xC3, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xFC, 0x01, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x7E, 0x7F, 0x00, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC,
  0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x08,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x1F, 0xF8, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x1B, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x80, 0x00, 0x7F, 0xF1, 0x00, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 18, 47, 17, 1, -46 },
  { 107, 21, 16, 27, 7, -46 },
  { 149, 40, 46, 42, 2, -46 },
  { 379, 33, 53, 36, 2, -49 },
  { 598, 45, 48, 53, 5, -47 },
  { 868, 41, 48, 44, 2, -47 },
  { 1114, 9, 16, 15, 7, -46 },
  { 1132, 22, 56, 20, 3, -46 },
  { 1286, 22, 57, 20, -5, -47 },
  { 1443, 31, 31, 36, 6, -50 },
  { 1564, 31, 32, 37, 4, -39 },
  { 1688, 14, 16, 17, -3, -8 },
  { 1716, 18, 6, 21, 1, -20 },
  { 1730, 9, 10, 17, 1, -9 },
  { 1742, 33, 47, 24, -3, -47 },
  { 1936, 32, 48, 36, 3, -47 },
  { 2128, 22, 46, 36, 8, -46 },
  { 2255, 34, 47, 36, 0, -47 },
  { 2455, 33, 48, 36, 1, -47 },
  { 2653, 35, 46, 36, 0, -46 },
  { 2855, 33, 47, 36, 2, -46 },
  { 3049, 32, 48, 36, 4, -47 },
  { 3241, 33, 46, 36, 4, -46 },
  { 3431, 32, 48, 36, 3, -47 },
  { 3623, 31, 48, 36, 3, -47 },
  { 3809, 15, 37, 17, 1, -36 },
  { 3879, 19, 44, 17, -3, -36 },
  { 3984, 31, 33, 37, 4, -40 },
  { 4112, 31, 18, 37, 4, -32 },
  { 4182, 31, 33, 37, 4, -40 },
  { 4310, 25, 48, 29, 5, -47 },
  { 4460, 51, 52, 55, 3, -46 },
  { 4792, 38, 46, 38, -4, -46 },
  { 5011, 37, 46, 39, 2, -46 },
  { 5224, 37, 48, 39, 4, -47 },
  { 5446, 40, 46, 44, 2, -46 },
  { 5676, 34, 46, 34, 2, -46 },
  { 5872, 34, 46, 32, 2, -46 },
  { 6068, 39, 48, 44, 4, -47 },
  { 6302, 43, 46, 45, 2, -46 },
  { 6550, 28, 46, 22, -2, -46 },
  { 6711, 29, 59, 19, -10, -46 },
  { 6925, 41, 46, 38, 2, -46 },
  { 7161, 26, 46, 32, 2, -46 },
  { 7311, 54, 46, 55, 2, -46 },
  { 7622, 45, 46, 47, 2, -46 },
  { 7881, 41, 48, 47, 4, -47 },
  { 8127, 36, 46, 38, 2, -46 },
  { 8334, 41, 58, 47, 4, -47 },
  { 8632, 35, 46, 38, 2, -46 },
  { 8834, 33, 48, 33, 1, -47 },
  { 9032, 33, 46, 33, 6, -46 },
  { 9222, 40, 47, 44, 5, -46 },
  { 9457, 37, 46, 37, 6, -46 },
  { 9670, 55, 46, 56, 7, -46 },
  { 9987, 45, 46, 36, -4, -46 },
  { 10246, 34, 46, 34, 6, -46 },
  { 10442, 39, 46, 35, -1, -46 },
  { 10667, 26, 56, 20, -1, -46 },
  { 10849, 13, 47, 24, 7, -47 },
  { 10926, 26, 56, 20, -5, -46 },
  { 11108, 33, 30, 37, 2, -47 },
  { 11232, 27, 4, 26, -6, 6 },
  { 11246, 12, 11, 19, 9, -50 },
  { 11263, 33, 37, 37, 3, -36 },
  { 11416, 33, 50, 38, 2, -49 },
  { 11623, 28, 37, 30, 3, -36 },
  { 11753, 36, 50, 38, 3, -49 },
  { 11978, 29, 37, 34, 3, -36 },
  { 12113, 37, 66, 22, -7, -50 },
  { 12419, 35, 52, 38, 1, -36 },
  { 12647, 33, 49, 38, 2, -49 },
  { 12850, 17, 48, 18, 2, -48 },
  { 12952, 27, 64, 18, -8, -48 },
  { 13168, 34, 49, 34, 2, -49 },
  { 13377, 17, 49, 18, 2, -49 },
  { 13482, 52, 36, 57, 2, -36 },
  { 13716, 34, 36, 38, 1, -36 },
  { 13869, 31, 37, 37, 3, -36 },
  { 14013, 37, 52, 38, -2, -36 },
  { 14254, 33, 52, 38, 3, -36 },
  { 14469, 26, 36, 26, 2, -36 },
  { 14586, 28, 37, 29, 0, -36 },
  { 14716, 22, 44, 23, 3, -43 },
  { 14837, 32, 36, 38, 4, -35 },
  { 14981, 32, 35, 31, 3, -35 },
  { 15121, 47, 35, 48, 4, -35 },
  { 15327, 38, 35, 32, -3, -35 },
  { 15494, 41, 51, 31, -6, -35 },
  { 15756, 30, 35, 29, -1, -35 },
  { 15888, 25, 56, 23, 1, -46 },
  { 16063, 6, 64, 36, 16, -49 },
  { 16111, 26, 56, 23, -3, -46 },
  { 16293, 31, 10, 37, 4, -28 },
};

const GFXfont NotoSans_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_MEDIUMITALIC65PT7B_H_
