#ifndef _NOTOSANS_MEDIUMITALIC71PT7B_H_
#define _NOTOSANS_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xCF,
  0x1F, 0xC0, 0x1F, 0xF1, 0xF0, 0x3C, 0x01, 0xFE, 0x1F, 0x00, 0x80, 0x1F,
  0xC1, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00,
  0x03, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x03, 0xF8, 0x3E,
  0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x1F,
  0xF7, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0xE0,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0xFF, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00,
  0x3E, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x08, 0x00, 0x3C, 0x1F, 0xE0,
  0xE0, 0x07, 0xC3, 0xFE, 0x0F, 0xC0, 0x7C, 0x7F, 0xC0, 0xFF, 0xE7, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x07, 0xF8, 0x3F,
  0x00, 0xFE, 0x1F, 0x87, 0xFF, 0x8F, 0xC0, 0x3F, 0x0F, 0xE3, 0xFF, 0xF3,
  0xF8, 0x1F, 0xC7, 0xF1, 0xFF, 0xFC, 0x7E, 0x0F, 0xE1, 0xF8, 0xFF, 0xFF,
  0x9F, 0xC7, 0xF8, 0xFC, 0x7F, 0xCF, 0xE7, 0xFF, 0xFC, 0x7F, 0x1F, 0xC1,
  0xFC, 0xFF, 0xFE, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xFF, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xFF, 0x87, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0xE7, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40,
  0x03, 0xF0, 0x00, 0x38, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0xE0, 0x7C, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x0F, 0xFF, 0x9E, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xF0, 0x0F, 0xEF, 0x80, 0x00, 0x0F, 0xE7, 0xC0,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xF0, 0x7E,
  0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x8F, 0xF7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xEF, 0xE7, 0xFF, 0x1F,
  0xC7, 0xFC, 0x7F, 0x87, 0xE0, 0xFF, 0x0F, 0x81, 0xFC, 0x0C, 0x03, 0xF8,
  0x10, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x07, 0xF8,
  0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x38, 0x00,
  0x0F, 0xF0, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x20, 0x00,
  0x00, 0x7F, 0x81, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x07,
  0xFE, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x10, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x3F,
  0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0xFE, 0x07, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF,
  0xC7, 0xF0, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0xE1, 0xF0, 0x01, 0xFF, 0x08, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFC,
  0x7E, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xF9, 0xFC, 0x01, 0xFF, 0x03, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0x7F, 0x00,
  0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xF3, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0x8F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFE, 0x1F, 0x80,
  0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x3F, 0x00, 0xFF, 0xBF, 0xBF, 0xBF, 0xE0,
  0x7E, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x7F,
  0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x1F, 0xFE, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x8F, 0xF0,
  0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x00, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0x0F,
  0xE7, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xF3, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x00,
  0x40, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F,
  0xC0, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x87, 0xE0, 0x0F, 0xFF,
  0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xDF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xE3,
  0xF0, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xE3, 0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0xCF,
  0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFC,
  0x07, 0xE7, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xFF, 0xF0, 0x0F, 0xC3, 0xFF,
  0xFE, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0x80, 0xFF, 0xC0, 0x04, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x20, 0x3F, 0xE0, 0x07, 0x80, 0xFF, 0xFB, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFF,
  0xE7, 0xF0, 0x01, 0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFB,
  0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0x1F, 0xFF, 0xF1, 0xF8,
  0x00, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xF8, 0x00, 0x03,
  0xFF, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xFC, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x60, 0x3F, 0xE0, 0x01, 0xE0, 0x3F, 0xFC, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x17, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x02,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC3, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x0F,
  0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0xEF,
  0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF7, 0xFB,
  0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFE, 0x7F, 0x00, 0x0F,
  0xFF, 0xF1, 0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x00, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xFF, 0xC0,
  0x1F, 0xCF, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x10, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xCF,
  0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xEF, 0xE1, 0xFF, 0x3F, 0x87, 0xFC,
  0x07, 0xF7, 0xC0, 0x7F, 0xBF, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x3F,
  0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F,
  0xDF, 0xFF, 0xFE, 0x01, 0xFB, 0xFE, 0x7F, 0xE0, 0x3F, 0xBF, 0x01, 0xFF,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xC3, 0xFF,
  0xF0, 0x00, 0x1F, 0xC7, 0xFF, 0xF8, 0x00, 0x1F, 0x8F, 0xFF, 0xFC, 0x00,
  0x1F, 0x9F, 0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0x8F, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xF7, 0xFF, 0xC0,
  0x07, 0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0x00, 0x0F, 0xF3,
  0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xC0,
  0x07, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xFE,
  0x7F, 0x00, 0xFF, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xDF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xF0,
  0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0x0F, 0xFE, 0x03, 0xF8, 0xFF, 0xE0,
  0x1F, 0xCF, 0xFF, 0x00, 0xFE, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xC0, 0x7F,
  0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0x81, 0xFF, 0x00,
  0x0C, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x30, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0xC3, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE7, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xFC, 0x0F,
  0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF,
  0xE3, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0x83, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0x8F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x7C, 0x3F,
  0x80, 0x07, 0xF1, 0xF8, 0x07, 0xC7, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xDF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x9F, 0xFF,
  0x80, 0x00, 0x5F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x80, 0x00, 0x7F, 0xFC, 0x40, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph NotoSans_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 19, 52, 19, 1, -51 },
  { 125, 22, 19, 29, 8, -51 },
  { 178, 44, 51, 46, 2, -51 },
  { 459, 36, 58, 39, 2, -54 },
  { 720, 50, 52, 58, 5, -51 },
  { 1045, 45, 52, 49, 2, -51 },
  { 1338, 10, 19, 16, 8, -51 },
  { 1362, 24, 62, 22, 3, -51 },
  { 1548, 24, 62, 22, -5, -51 },
  { 1734, 33, 33, 39, 7, -54 },
  { 1871, 33, 34, 41, 5, -42 },
  { 2012, 15, 17, 19, -3, -8 },
  { 2044, 18, 6, 22, 2, -22 },
  { 2058, 10, 10, 19, 1, -9 },
  { 2071, 36, 51, 27, -3, -51 },
  { 2301, 34, 52, 39, 4, -51 },
  { 2522, 23, 51, 39, 9, -51 },
  { 2669, 38, 51, 39, 0, -51 },
  { 2912, 37, 52, 39, 1, -51 },
  { 3153, 38, 51, 39, 0, -51 },
  { 3396, 36, 52, 39, 2, -51 },
  { 3630, 35, 52, 39, 4, -51 },
  { 3858, 36, 51, 39, 5, -51 },
  { 4088, 36, 52, 39, 3, -51 },
  { 4322, 34, 52, 39, 3, -51 },
  { 4543, 16, 40, 19, 1, -39 },
  { 4623, 21, 48, 19, -4, -39 },
  { 4749, 33, 36, 41, 5, -44 },
  { 4898, 33, 20, 41, 5, -35 },
  { 4981, 33, 36, 41, 5, -44 },
  { 5130, 28, 52, 31, 5, -51 },
  { 5312, 55, 57, 60, 4, -51 },
  { 5704, 42, 51, 41, -4, -51 },
  { 5972, 39, 51, 43, 3, -51 },
  { 6221, 40, 52, 42, 5, -51 },
  { 6481, 42, 51, 48, 3, -51 },
  { 6749, 37, 51, 37, 3, -51 },
  { 6985, 37, 51, 35, 3, -51 },
  { 7221, 42, 52, 48, 5, -51 },
  { 7494, 46, 51, 49, 3, -51 },
  { 7788, 30, 51, 24, -2, -51 },
  { 7980, 32, 65, 21, -11, -51 },
  { 8240, 44, 51, 41, 3, -51 },
  { 8521, 27, 51, 35, 3, -51 },
  { 8694, 58, 51, 61, 3, -51 },
  { 9064, 49, 51, 51, 3, -51 },
  { 9377, 44, 52, 51, 5, -51 },
  { 9663, 38, 51, 41, 3, -51 },
  { 9906, 44, 63, 51, 5, -51 },
  { 10253, 38, 51, 42, 3, -51 },
  { 10496, 36, 52, 36, 1, -51 },
  { 10730, 36, 51, 36, 6, -51 },
  { 10960, 44, 52, 48, 5, -51 },
  { 11246, 41, 51, 40, 6, -51 },
  { 11508, 61, 51, 62, 7, -51 },
  { 11897, 49, 51, 39, -4, -51 },
  { 12210, 37, 51, 37, 7, -51 },
  { 12446, 42, 51, 38, -1, -51 },
  { 12714, 28, 62, 21, -1, -51 },
  { 12931, 14, 51, 27, 8, -51 },
  { 13021, 28, 62, 21, -5, -51 },
  { 13238, 36, 32, 40, 2, -51 },
  { 13382, 30, 5, 28, -7, 6 },
  { 13401, 13, 11, 21, 10, -54 },
  { 13419, 37, 40, 41, 3, -39 },
  { 13604, 36, 55, 41, 2, -54 },
  { 13852, 30, 40, 33, 3, -39 },
  { 14002, 40, 55, 41, 3, -54 },
  { 14277, 32, 40, 37, 3, -39 },
  { 14437, 40, 71, 24, -8, -54 },
  { 14792, 38, 56, 41, 2, -39 },
  { 15058, 36, 54, 42, 2, -54 },
  { 15301, 18, 53, 19, 2, -53 },
  { 15421, 29, 70, 19, -9, -53 },
  { 15675, 37, 54, 37, 2, -54 },
  { 15925, 19, 54, 19, 2, -54 },
  { 16054, 57, 39, 63, 2, -39 },
  { 16332, 36, 39, 42, 2, -39 },
  { 16508, 34, 40, 40, 3, -39 },
  { 16678, 40, 56, 41, -2, -39 },
  { 16958, 37, 56, 41, 3, -39 },
  { 17217, 29, 39, 29, 2, -39 },
  { 17359, 30, 40, 32, 0, -39 },
  { 17509, 24, 48, 25, 3, -47 },
  { 17653, 36, 39, 42, 4, -38 },
  { 17829, 35, 38, 34, 3, -38 },
  { 17996, 52, 38, 53, 4, -38 },
  { 18243, 41, 38, 35, -3, -38 },
  { 18438, 44, 55, 34, -6, -38 },
  { 18741, 33, 38, 32, -1, -38 },
  { 18898, 28, 62, 25, 1, -51 },
  { 19115, 6, 71, 39, 18, -54 },
  { 19169, 28, 62, 25, -3, -51 },
  { 19386, 33, 10, 41, 5, -30 },
};

const GFXfont NotoSans_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_MEDIUMITALIC71PT7B_H_
