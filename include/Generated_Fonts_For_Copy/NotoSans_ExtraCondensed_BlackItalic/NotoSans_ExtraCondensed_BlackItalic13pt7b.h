#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x0C, 0xC0, 0x7F, 0x6D, 0x80, 0x1E, 0x29, 0xFB,
  0xF2, 0xDF, 0xBF, 0x2C, 0xD0, 0x08, 0xF3, 0xDC, 0x70, 0xE1, 0xB6, 0xF8,
  0x82, 0x00, 0x73, 0x7B, 0x2D, 0x15, 0xAF, 0xB8, 0xFC, 0xD6, 0x4B, 0x67,
  0x00, 0x3C, 0x34, 0x3C, 0x38, 0x7F, 0xFE, 0xDC, 0xFC, 0x7E, 0x7B, 0x00,
  0x19, 0x8C, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x80, 0x30, 0x86, 0x31, 0x88,
  0xC6, 0x33, 0x19, 0x80, 0x35, 0xBE, 0xEF, 0xA8, 0x21, 0x09, 0xF2, 0x10,
  0x80, 0x76, 0x6C, 0xFE, 0xF0, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0xE0, 0x3C, 0xF6, 0xDB, 0x6F, 0xBD, 0x9E, 0x70, 0x3B, 0xFE, 0xE3, 0x18,
  0xCE, 0x60, 0x3D, 0xB4, 0xC7, 0x18, 0xC6, 0x3E, 0xF8, 0x3C, 0xB0, 0xCE,
  0x38, 0x61, 0xBE, 0xF0, 0x0C, 0x73, 0xCF, 0x7B, 0xFF, 0xC6, 0x30, 0x3C,
  0xF2, 0x1E, 0x7C, 0x71, 0xBE, 0xF0, 0x1E, 0x75, 0x83, 0xE7, 0xDD, 0xBF,
  0x3C, 0x70, 0x3E, 0xF8, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0xE0, 0x3D, 0xF6,
  0xCE, 0x39, 0xED, 0xFE, 0x70, 0x3D, 0xF6, 0xDB, 0x7D, 0xB1, 0xBE, 0xF0,
  0x6C, 0x01, 0xB0, 0x33, 0x00, 0x07, 0x66, 0xC0, 0x04, 0x77, 0xB8, 0x3C,
  0x30, 0x40, 0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x1E, 0x7F, 0x62, 0x00, 0x79,
  0xF1, 0x8E, 0x31, 0x80, 0x18, 0xE0, 0x1F, 0x18, 0xDB, 0xAB, 0x55, 0x6F,
  0xBF, 0x7D, 0xA4, 0x66, 0x1E, 0x00, 0x0E, 0x3C, 0x78, 0xF3, 0x67, 0xDF,
  0xB3, 0xE6, 0x3E, 0x7D, 0x9B, 0xE7, 0xCD, 0xBB, 0x7E, 0xF8, 0x1E, 0x79,
  0xC3, 0x06, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x7D, 0x9B, 0x36, 0x6D, 0xFB,
  0x7E, 0xF0, 0x3C, 0xF6, 0x1E, 0x79, 0x8E, 0x3E, 0xF0, 0x3C, 0xF6, 0x18,
  0x79, 0x8E, 0x30, 0xC0, 0x1F, 0x3E, 0x70, 0x60, 0x6E, 0xEE, 0xEC, 0x7C,
  0x7C, 0x33, 0x36, 0x66, 0x7E, 0x7E, 0x6E, 0xEC, 0xCC, 0xCC, 0x7C, 0xC3,
  0x0C, 0x31, 0xC6, 0x18, 0xF0, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x30,
  0xCF, 0x38, 0x37, 0x3E, 0x6C, 0x78, 0x78, 0x78, 0xFC, 0xDC, 0xCC, 0x31,
  0x98, 0xC6, 0x33, 0x9F, 0xF0, 0x39, 0xCE, 0xF7, 0xBD, 0xEE, 0x7F, 0x9F,
  0x6F, 0xDB, 0x7E, 0xDB, 0x00, 0x33, 0x3B, 0x7B, 0x7B, 0x7E, 0x7E, 0xEE,
  0xCE, 0xCE, 0x1E, 0x6D, 0x9B, 0x36, 0x7C, 0xFB, 0xBE, 0x78, 0x3C, 0x7D,
  0xBB, 0x67, 0xCF, 0x38, 0x60, 0xC0, 0x1E, 0x6D, 0x9B, 0x36, 0x7C, 0xFB,
  0xBE, 0x78, 0x30, 0x70, 0x3C, 0x7D, 0xBB, 0x67, 0xCF, 0x3E, 0x6E, 0xCC,
  0x3D, 0xF6, 0x1C, 0x38, 0x69, 0xBE, 0xF0, 0xFF, 0xE7, 0x18, 0x61, 0x8E,
  0x30, 0xC0, 0x37, 0x76, 0x66, 0x66, 0x6E, 0x6C, 0xEC, 0x7C, 0x78, 0xCF,
  0x9B, 0x36, 0xCD, 0x9E, 0x3C, 0x78, 0xE0, 0xCD, 0xF7, 0x6D, 0xDB, 0x7C,
  0xFF, 0x3F, 0xCE, 0xE3, 0xB8, 0xCE, 0x00, 0x3B, 0x1E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x6C, 0xEE, 0xEF, 0xF9, 0xE3, 0x87, 0x0C, 0x18, 0x30, 0xE0,
  0x3F, 0x3E, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x7C, 0xFC, 0x1C, 0x73, 0x0C,
  0x30, 0xC2, 0x18, 0x61, 0x87, 0x38, 0xC9, 0x36, 0xDB, 0x60, 0x39, 0xC6,
  0x31, 0x98, 0xC6, 0x31, 0x99, 0xC0, 0x18, 0x63, 0x9B, 0x6F, 0x30, 0xF8,
  0xCC, 0x3E, 0xD9, 0xB6, 0x6D, 0xDF, 0x1E, 0x00, 0x30, 0xC7, 0x1F, 0x7D,
  0xB6, 0xFB, 0xFB, 0xE0, 0x3D, 0xE6, 0x30, 0xC3, 0xC7, 0x00, 0x06, 0x0C,
  0x39, 0xE6, 0xCD, 0xB3, 0x6E, 0xF8, 0xF0, 0x3D, 0xB7, 0xFE, 0xC3, 0xE7,
  0x80, 0x0E, 0x38, 0x61, 0xE7, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x87, 0x0C,
  0x00, 0x3E, 0xD9, 0xB6, 0x6D, 0xDF, 0x1E, 0x0C, 0xF9, 0xE0, 0x30, 0xC6,
  0x1F, 0x7D, 0xB6, 0xF3, 0xDB, 0x60, 0x33, 0x06, 0x66, 0x6C, 0xCC, 0x0C,
  0x30, 0x06, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x3C, 0xE0, 0x30, 0x61, 0xC3,
  0x77, 0xCF, 0x1E, 0x7C, 0xD9, 0xB8, 0x33, 0x76, 0x66, 0x6C, 0xCC, 0x7F,
  0xBF, 0xDB, 0x6D, 0xBD, 0xDE, 0xDB, 0x6C, 0x7D, 0xF6, 0xDB, 0xCF, 0x6D,
  0x80, 0x3D, 0xB6, 0xF3, 0xDF, 0xE7, 0x00, 0x3E, 0x7C, 0xD9, 0xB7, 0x6F,
  0x9F, 0x30, 0x61, 0x80, 0x3E, 0xD9, 0xB6, 0x6D, 0xDF, 0x1E, 0x0C, 0x18,
  0x60, 0x7B, 0xD8, 0xCC, 0x63, 0x00, 0x7B, 0x58, 0xE3, 0x7B, 0xC0, 0x31,
  0x9E, 0xF6, 0x31, 0x9E, 0x70, 0x6E, 0xD9, 0xB3, 0x6D, 0xDF, 0x1E, 0x00,
  0xDF, 0x6F, 0x3C, 0xE3, 0x8E, 0x00, 0xDB, 0xFD, 0xBF, 0x9F, 0xCF, 0xE6,
  0xE3, 0x70, 0x37, 0x3E, 0x1C, 0x18, 0x3C, 0x6C, 0xEC, 0x37, 0x36, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0x3E, 0x78, 0x61, 0xC3, 0x0F,
  0x3E, 0x00, 0x19, 0xCC, 0x6E, 0x61, 0x8C, 0x63, 0x18, 0xFF, 0xF8, 0x39,
  0xC6, 0x71, 0x8C, 0xC6, 0x67, 0x38, 0x67, 0xF8, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 6, 3, 6, 1, -9 },
  { 9, 7, 9, 7, 0, -9 },
  { 17, 6, 11, 6, 0, -10 },
  { 26, 9, 9, 10, 1, -9 },
  { 37, 8, 9, 8, 0, -9 },
  { 46, 3, 3, 3, 1, -9 },
  { 48, 5, 12, 4, 0, -10 },
  { 56, 5, 12, 4, -1, -10 },
  { 64, 5, 6, 6, 1, -10 },
  { 68, 5, 7, 7, 1, -8 },
  { 73, 4, 4, 3, -1, -2 },
  { 75, 4, 2, 4, 0, -4 },
  { 76, 2, 2, 3, 0, -2 },
  { 77, 7, 9, 5, -1, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 5, 9, 6, 1, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 7, 9, 6, 0, -9 },
  { 134, 7, 9, 6, 0, -9 },
  { 142, 6, 9, 6, 0, -9 },
  { 149, 6, 9, 6, 0, -9 },
  { 156, 3, 7, 3, 0, -7 },
  { 159, 4, 9, 3, -1, -7 },
  { 164, 6, 7, 7, 0, -8 },
  { 170, 5, 5, 7, 1, -7 },
  { 174, 5, 7, 7, 1, -8 },
  { 179, 6, 9, 5, 0, -9 },
  { 186, 9, 10, 9, 0, -9 },
  { 198, 7, 9, 7, -1, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 7, 9, 6, 0, -9 },
  { 222, 7, 9, 7, 0, -9 },
  { 230, 6, 9, 5, 0, -9 },
  { 237, 6, 9, 5, 0, -9 },
  { 244, 8, 9, 7, 0, -9 },
  { 253, 8, 9, 7, 0, -9 },
  { 262, 6, 9, 5, 0, -9 },
  { 269, 6, 12, 4, -2, -9 },
  { 278, 8, 9, 7, 0, -9 },
  { 287, 5, 9, 5, 0, -9 },
  { 293, 10, 9, 10, 0, -9 },
  { 305, 8, 9, 8, 0, -9 },
  { 314, 7, 9, 7, 0, -9 },
  { 322, 7, 9, 6, 0, -9 },
  { 330, 7, 11, 7, 0, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 6, 0, -9 },
  { 355, 6, 9, 6, 1, -9 },
  { 362, 8, 9, 7, 0, -9 },
  { 371, 7, 9, 7, 1, -9 },
  { 379, 10, 9, 10, 1, -9 },
  { 391, 8, 9, 7, -1, -9 },
  { 400, 7, 9, 6, 1, -9 },
  { 408, 8, 9, 6, -1, -9 },
  { 417, 6, 12, 4, -1, -10 },
  { 426, 3, 9, 5, 1, -9 },
  { 430, 5, 12, 4, -1, -10 },
  { 438, 6, 6, 6, 0, -9 },
  { 443, 5, 1, 5, -1, 1 },
  { 444, 3, 2, 4, 2, -10 },
  { 445, 7, 7, 6, 0, -7 },
  { 452, 6, 10, 6, 0, -10 },
  { 460, 6, 7, 5, 0, -7 },
  { 466, 7, 10, 6, 0, -10 },
  { 475, 6, 7, 6, 0, -7 },
  { 481, 7, 13, 4, -1, -10 },
  { 493, 7, 10, 6, 0, -7 },
  { 502, 6, 10, 6, 0, -10 },
  { 510, 4, 10, 3, 0, -10 },
  { 515, 6, 13, 3, -2, -10 },
  { 525, 7, 10, 6, 0, -10 },
  { 534, 4, 10, 3, 0, -10 },
  { 539, 9, 7, 9, 0, -7 },
  { 547, 6, 7, 6, 0, -7 },
  { 553, 6, 7, 6, 0, -7 },
  { 559, 7, 10, 6, -1, -7 },
  { 568, 7, 10, 6, 0, -7 },
  { 577, 5, 7, 5, 0, -7 },
  { 582, 5, 7, 5, 0, -7 },
  { 587, 5, 9, 4, 0, -9 },
  { 593, 7, 7, 6, 0, -7 },
  { 600, 6, 7, 6, 1, -7 },
  { 606, 9, 7, 9, 1, -7 },
  { 614, 8, 7, 6, -1, -7 },
  { 621, 8, 10, 6, -1, -7 },
  { 631, 7, 7, 5, -1, -7 },
  { 638, 5, 11, 4, 0, -9 },
  { 645, 1, 13, 5, 2, -10 },
  { 647, 5, 11, 4, -1, -9 },
  { 654, 6, 3, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC13PT7B_H_
