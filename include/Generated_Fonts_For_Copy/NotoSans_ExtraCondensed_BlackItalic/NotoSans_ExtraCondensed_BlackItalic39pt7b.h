#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8,
  0xF8, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0xF8, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x03, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xC0, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x00,
  0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0x81, 0xF6, 0x30, 0x3E, 0xC0, 0x07, 0xD8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x84, 0x0D, 0xF0, 0x41, 0xBE,
  0x1E, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x3E, 0x03, 0xFF,
  0x03, 0xC0, 0x3E, 0xF8, 0x7C, 0x07, 0xCF, 0x8F, 0x80, 0x7C, 0xF8, 0xF8,
  0x07, 0x8F, 0x1F, 0x00, 0xF8, 0xF1, 0xF0, 0x0F, 0x9F, 0x3E, 0x00, 0xF9,
  0xF3, 0xE0, 0x0F, 0x9E, 0x7C, 0x7C, 0xFB, 0xE7, 0x9F, 0xEF, 0xFE, 0xFB,
  0xFF, 0x7F, 0xDF, 0x3F, 0xF7, 0xF9, 0xF7, 0xDF, 0x3F, 0x3E, 0x79, 0xF0,
  0x03, 0xEF, 0x9F, 0x00, 0x7C, 0xF9, 0xF0, 0x07, 0x8F, 0x9F, 0x00, 0xF8,
  0xF1, 0xF0, 0x1F, 0x0F, 0x1E, 0x01, 0xF0, 0xF3, 0xE0, 0x3E, 0x0F, 0x3E,
  0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0x80, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x07, 0xFC, 0x7E, 0x0F, 0xFC, 0xFE, 0x1F,
  0xFE, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x7F, 0xF8, 0x7E, 0x7F, 0xF8, 0xFE,
  0x3F, 0xF0, 0xFE, 0x3F, 0xE0, 0xFE, 0x3F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x7F, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x43, 0xE0,
  0x73, 0xE0, 0x7F, 0xE6, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFE, 0xF8, 0x7C, 0xFC, 0x3C, 0xFC,
  0x18, 0x70, 0x08, 0x40, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x8F, 0xC7,
  0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x00, 0x7F, 0xF7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xCF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F,
  0xCF, 0xC7, 0xF3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7F, 0x1F, 0x9F, 0x87, 0xE7,
  0xE1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xC7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0x3D, 0xF8, 0x39, 0xF8, 0x13, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0xC0, 0xE1, 0xF8, 0x18, 0x3F, 0x02, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xBF,
  0xC0, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF1,
  0x00, 0xFE, 0x3C, 0x7F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xDF, 0xC0, 0xFB, 0xF0,
  0x1E, 0x7E, 0x07, 0xCF, 0xC1, 0xF3, 0xF8, 0x7C, 0x7E, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x63, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x20,
  0x3F, 0x8E, 0x3F, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF3, 0x00, 0xFD, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xF9, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x7F, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0xBF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xE7, 0xE1, 0xFC, 0xFE, 0x3F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E,
  0x3F, 0x8F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0x87, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F,
  0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFB, 0xF0, 0x1C, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x20, 0x7F, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0x83,
  0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x60, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1E, 0xFF, 0x10, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x78,
  0x7F, 0x9E, 0x1F, 0x1F, 0xFB, 0xE7, 0xC7, 0xFE, 0x7C, 0xF1, 0xFF, 0xCF,
  0x9E, 0x7C, 0x79, 0xF7, 0xCF, 0x1F, 0x3C, 0xF3, 0xE3, 0xC7, 0x9E, 0x7C,
  0x78, 0xF7, 0xCF, 0x0F, 0x1E, 0xF1, 0xE3, 0xE7, 0x9E, 0x7C, 0x7C, 0xF3,
  0xCF, 0x8F, 0x1E, 0x79, 0xF3, 0xE7, 0x8F, 0x1F, 0xFF, 0xE1, 0xE3, 0xFB,
  0xFC, 0x3C, 0x3E, 0x7E, 0x07, 0xC1, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x04, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7D, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFB, 0xF0,
  0x1F, 0xBF, 0x03, 0xFB, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x3F,
  0x07, 0xE3, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0x7F, 0x03, 0xF7, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x87, 0xF3, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xBC, 0x0F,
  0xE0, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x40, 0x7F, 0xBC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x9F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE7, 0xF0, 0x7E,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF1,
  0xFE, 0x3F, 0x9F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x02, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xF1, 0xFC, 0xFF, 0x87, 0xF3, 0xFE, 0x1F, 0xCF, 0xF8, 0x7E, 0x3F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x87,
  0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xE3,
  0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF,
  0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xCF,
  0xFF, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFB,
  0xF0, 0x3F, 0x7F, 0xF7, 0xE0, 0x7E, 0xFF, 0xDF, 0xC0, 0xFD, 0xFF, 0xBF,
  0x81, 0xFB, 0xFE, 0x7E, 0x07, 0xF7, 0xFC, 0xFC, 0x0F, 0xCF, 0xF9, 0xF8,
  0x1F, 0x9F, 0xE7, 0xF0, 0x3F, 0x3F, 0xCF, 0xE0, 0x7E, 0x7F, 0x1F, 0x81,
  0xF8, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x7E, 0x07, 0xE3, 0xF1, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x87,
  0xE0, 0x7F, 0xC3, 0xF0, 0x3F, 0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8,
  0xFE, 0x0F, 0xFC, 0x7E, 0x07, 0xFF, 0x3F, 0x07, 0xFF, 0x9F, 0x83, 0xFF,
  0xCF, 0xC1, 0xFF, 0xEF, 0xE0, 0xFD, 0xF7, 0xE0, 0x7E, 0xFF, 0xF0, 0x7F,
  0x7F, 0xF8, 0x3F, 0x3F, 0xFC, 0x1F, 0x9F, 0xFE, 0x0F, 0xCF, 0xFE, 0x07,
  0xE3, 0xFF, 0x07, 0xF1, 0xFF, 0x83, 0xF0, 0xFF, 0xC1, 0xF8, 0x7F, 0xC0,
  0xFC, 0x3F, 0xE0, 0x7E, 0x1F, 0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x03, 0xFC,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFB, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8,
  0x7F, 0x3F, 0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFB, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8,
  0x7F, 0x3F, 0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x03,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xC1, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xF1, 0xC0, 0xFE, 0x04, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x20, 0x3F, 0x87, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x0F, 0xC1, 0xFD, 0xF8, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0x3F, 0xBF, 0x87,
  0xF0, 0xFC, 0xFE, 0x1F, 0xC7, 0xF3, 0xF8, 0xFF, 0x1F, 0xCF, 0xE3, 0xFC,
  0x7E, 0x3F, 0x9F, 0xE3, 0xF8, 0xFC, 0x7F, 0x8F, 0xC3, 0xF1, 0xFE, 0x3F,
  0x0F, 0xCF, 0xF9, 0xFC, 0x3F, 0x3F, 0xE7, 0xE0, 0xFD, 0xFF, 0x9F, 0x83,
  0xF7, 0xFE, 0xFE, 0x0F, 0xDF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF3,
  0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xFC, 0x01,
  0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFB, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x1F, 0xBF,
  0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0xFC, 0x7C, 0x3F,
  0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC0, 0x7F, 0xF0,
  0x0F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x3F, 0x1F, 0x03, 0xC7, 0xE1, 0xFC, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x7E,
  0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8,
  0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x3F, 0x9F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7D, 0xFE, 0x0F, 0xCF, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xDC,
  0x7F, 0x04, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFE, 0x30, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xCF, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0x7C, 0x03, 0xE7, 0xC0, 0x00,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0xFD,
  0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x0C, 0x7F,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xB0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x83,
  0xF0, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F,
  0x3F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x06, 0x07,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE7,
  0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE,
  0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF1,
  0xFC, 0x7E, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE1, 0xFC,
  0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x03, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F,
  0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x07,
  0xC7, 0x83, 0xC0, 0x3E, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0x9F, 0xCF,
  0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87,
  0xE3, 0xF1, 0xFC, 0x3F, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFC, 0x7E, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87,
  0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0x80, 0xFB, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF9, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x8F,
  0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFD,
  0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF1, 0xFD, 0xF8, 0xFC, 0xFC, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xE3, 0xC0, 0x3E, 0x7E, 0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xBF, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87,
  0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE3, 0xF0, 0x3F, 0x3E, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x8F, 0x0F, 0xBE, 0x0F, 0xBE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0x9C, 0x3F, 0x84, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x81, 0xF8, 0xC3, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x9F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC4, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0x8F,
  0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFE, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xF7, 0xC0,
  0xFC, 0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0xFE,
  0x7E, 0x3F, 0x1F, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0xFC, 0x1F,
  0xBF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x8F, 0xFF, 0xCF, 0xF1, 0xFB,
  0xF9, 0xFE, 0x3F, 0x7E, 0x3F, 0xCF, 0xCF, 0xCF, 0xF9, 0xF9, 0xF9, 0xFF,
  0x7F, 0x3F, 0x3F, 0xEF, 0xC7, 0xEF, 0xFD, 0xF8, 0xFD, 0xFF, 0x7E, 0x1F,
  0xBD, 0xEF, 0xC3, 0xFF, 0xBD, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF,
  0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF,
  0x9F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF8,
  0x0F, 0xCF, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F,
  0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x02, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x5F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 28, 10, 0, -28 },
  { 43, 16, 10, 18, 4, -28 },
  { 63, 22, 28, 21, 0, -28 },
  { 140, 19, 32, 18, 0, -30 },
  { 216, 28, 28, 31, 2, -28 },
  { 314, 24, 28, 23, 0, -28 },
  { 398, 8, 10, 9, 4, -28 },
  { 408, 14, 35, 11, 0, -29 },
  { 470, 14, 35, 11, -3, -29 },
  { 532, 16, 18, 17, 3, -30 },
  { 568, 17, 19, 20, 2, -23 },
  { 609, 9, 11, 10, -2, -6 },
  { 622, 12, 6, 12, 0, -13 },
  { 631, 7, 7, 10, 0, -7 },
  { 638, 21, 28, 15, -2, -28 },
  { 712, 18, 28, 18, 1, -28 },
  { 775, 16, 28, 18, 3, -28 },
  { 831, 19, 28, 18, -1, -28 },
  { 898, 19, 28, 18, 0, -28 },
  { 965, 19, 28, 18, 0, -28 },
  { 1032, 18, 28, 18, 1, -28 },
  { 1095, 19, 28, 18, 1, -28 },
  { 1162, 20, 28, 18, 1, -28 },
  { 1232, 19, 28, 18, 0, -28 },
  { 1299, 19, 28, 18, 0, -28 },
  { 1366, 10, 22, 10, 0, -22 },
  { 1394, 12, 27, 10, -2, -22 },
  { 1435, 17, 20, 20, 2, -24 },
  { 1478, 17, 14, 20, 2, -21 },
  { 1508, 17, 20, 20, 2, -24 },
  { 1551, 16, 28, 15, 1, -28 },
  { 1607, 27, 31, 28, 1, -28 },
  { 1712, 20, 28, 21, -2, -28 },
  { 1782, 21, 28, 20, 0, -28 },
  { 1856, 20, 28, 18, 1, -28 },
  { 1926, 21, 28, 21, 0, -28 },
  { 2000, 18, 28, 16, 0, -28 },
  { 2063, 18, 28, 16, 0, -28 },
  { 2126, 22, 28, 21, 1, -28 },
  { 2203, 24, 28, 22, 0, -28 },
  { 2287, 18, 28, 15, -1, -28 },
  { 2350, 18, 37, 11, -6, -28 },
  { 2434, 24, 28, 20, 0, -28 },
  { 2518, 14, 28, 16, 0, -28 },
  { 2567, 31, 28, 29, 0, -28 },
  { 2676, 25, 28, 24, 0, -28 },
  { 2764, 21, 28, 22, 1, -28 },
  { 2838, 20, 28, 19, 0, -28 },
  { 2908, 21, 35, 22, 1, -28 },
  { 3000, 20, 28, 20, 0, -28 },
  { 3070, 20, 28, 17, -1, -28 },
  { 3140, 17, 28, 17, 3, -28 },
  { 3200, 22, 28, 21, 1, -28 },
  { 3277, 20, 28, 20, 4, -28 },
  { 3347, 30, 28, 29, 3, -28 },
  { 3452, 24, 28, 20, -2, -28 },
  { 3536, 19, 28, 19, 4, -28 },
  { 3603, 22, 28, 17, -2, -28 },
  { 3680, 16, 36, 11, -2, -29 },
  { 3752, 9, 28, 15, 4, -28 },
  { 3784, 16, 36, 11, -3, -29 },
  { 3856, 19, 19, 18, -1, -28 },
  { 3902, 16, 4, 15, -4, 3 },
  { 3910, 8, 6, 13, 6, -30 },
  { 3916, 19, 22, 19, 1, -22 },
  { 3969, 20, 30, 19, -1, -30 },
  { 4044, 16, 22, 16, 1, -22 },
  { 4088, 20, 30, 19, 1, -30 },
  { 4163, 17, 22, 18, 1, -22 },
  { 4210, 21, 39, 12, -4, -30 },
  { 4313, 21, 31, 19, -1, -22 },
  { 4395, 19, 30, 19, -1, -30 },
  { 4467, 12, 30, 10, 0, -30 },
  { 4512, 17, 39, 10, -5, -30 },
  { 4595, 22, 30, 19, -1, -30 },
  { 4678, 13, 30, 10, -1, -30 },
  { 4727, 29, 22, 28, -1, -22 },
  { 4807, 19, 22, 19, -1, -22 },
  { 4860, 17, 22, 19, 1, -22 },
  { 4907, 20, 31, 19, -2, -22 },
  { 4985, 20, 31, 19, 0, -22 },
  { 5063, 16, 22, 14, 0, -22 },
  { 5107, 16, 22, 15, 0, -22 },
  { 5151, 13, 26, 13, 2, -26 },
  { 5194, 19, 22, 19, 1, -22 },
  { 5247, 18, 22, 18, 2, -22 },
  { 5297, 27, 22, 26, 2, -22 },
  { 5372, 22, 22, 18, -2, -22 },
  { 5433, 22, 31, 18, -2, -22 },
  { 5519, 19, 22, 15, -2, -22 },
  { 5572, 16, 34, 13, 0, -28 },
  { 5640, 5, 39, 15, 5, -30 },
  { 5665, 15, 34, 13, -2, -28 },
  { 5729, 18, 7, 20, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC39PT7B_H_
