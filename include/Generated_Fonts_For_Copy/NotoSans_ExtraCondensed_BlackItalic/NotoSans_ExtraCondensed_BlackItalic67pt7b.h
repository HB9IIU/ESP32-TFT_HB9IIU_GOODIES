#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x71, 0xF8, 0x03, 0xFE,
  0x70, 0x70, 0x03, 0xFE, 0x70, 0x10, 0x07, 0xFE, 0xF0, 0x00, 0x07, 0xFE,
  0xF0, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0x7F, 0xE0, 0x00, 0x07, 0x3F, 0xE0, 0x20, 0x07, 0x3F, 0xE0, 0x38, 0x0F,
  0x3F, 0xE0, 0x3C, 0x0F, 0x7F, 0xE0, 0x7F, 0x0E, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xFC, 0x1F, 0xF0, 0xFF, 0x1F, 0xE7, 0xFC,
  0x3F, 0xF8, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF8,
  0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xC7,
  0xFD, 0xFF, 0x3F, 0xFC, 0x3F, 0xCF, 0xF8, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF0, 0xFF, 0x01, 0x80, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x18, 0x1F, 0xF0, 0x01, 0xE1, 0xFF, 0x00, 0x1F, 0x1F,
  0xF0, 0x13, 0xFD, 0xFE, 0x0F, 0x3F, 0xFF, 0xE7, 0xF3, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xE0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0x1F,
  0xF8, 0x0F, 0xE1, 0xFF, 0x80, 0x7E, 0x1F, 0xF0, 0x03, 0xC0, 0xFC, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF0, 0x07, 0x81, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF,
  0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xC1, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0x03, 0xF9, 0xFF,
  0xC0, 0x7C, 0x7F, 0xF0, 0x0E, 0x3F, 0xFC, 0x03, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0xF0, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0xF0, 0x1F, 0xFC, 0x00, 0x60, 0x0F,
  0xFE, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x20,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x80, 0x01, 0xFF, 0xF0, 0xE0, 0x01, 0xFF, 0xE0, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFD, 0xFF, 0xC0, 0x00, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xBF, 0xF8, 0x00,
  0x3F, 0xCF, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xE0,
  0x03, 0xFC, 0x7F, 0xF0, 0x01, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0x87, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x3F,
  0xF8, 0x43, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x03, 0xFF, 0xE0, 0xE0, 0x07,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x1F, 0xFC,
  0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x40, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x3C, 0x07, 0xFF, 0x04,
  0x00, 0xFF, 0xC2, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0,
  0x3F, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0xC7, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF3, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x3F, 0x87, 0xF8,
  0x3F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0x03,
  0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xF0, 0x7F,
  0x83, 0xF1, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFF, 0x0F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF,
  0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0x80, 0x60, 0x03,
  0xFF, 0xC0, 0x08, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x20, 0x07, 0xFF, 0x80, 0x30, 0x01, 0xFF, 0xF0, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0x00, 0x3F, 0xFE, 0x00, 0x10, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x20, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF9,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xBF, 0xEF, 0xFE, 0x00, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0xCF, 0xFC, 0x00,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0x9F, 0xFC,
  0x01, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xE3, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0xBF, 0xF3, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xCF, 0xFD, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC7,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF,
  0x3F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE,
  0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0xE0,
  0x1C, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x80,
  0x03, 0xFF, 0xC0, 0x30, 0x00, 0xFF, 0xF0, 0x0F, 0x00, 0x7F, 0xF8, 0x07,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xF3, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0x00, 0x7F, 0xF7, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xBF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x9F, 0xFC,
  0x03, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE,
  0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xE0, 0x1F,
  0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0x9F, 0xF0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x03, 0xFF, 0x9F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0x01, 0xFF, 0xE0, 0x10, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x08, 0x0F, 0xFF, 0x01, 0x80,
  0xFF, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xEF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFE, 0x3F, 0xF8, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC,
  0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x02, 0x0F, 0xFE, 0x00, 0x30, 0x7F, 0xF8, 0x0F, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x20, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x11, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x1F, 0xE7, 0xFF, 0x00, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x80, 0x00,
  0xFF, 0xE0, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x8F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xF7,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF,
  0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFF,
  0x80, 0x3F, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x1F, 0xFC,
  0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF,
  0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF,
  0x81, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xFC, 0x00, 0x3F,
  0xF7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF,
  0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0x9F, 0xFC, 0x00, 0x0E, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x80,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xC3,
  0xE0, 0x3F, 0xF8, 0x18, 0x07, 0xFF, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x40, 0x0F,
  0xFF, 0x0F, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x08, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0x07, 0xFE, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0xFE, 0x7F, 0xE0,
  0x7F, 0xE7, 0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xEF, 0xFE, 0x07,
  0xFE, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xBF, 0xDF, 0xF8, 0x07, 0xFD,
  0xFE, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x09, 0xFF,
  0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFD, 0x00,
  0x03, 0xFF, 0xC8, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 21, 49, 17, 0, -48 },
  { 130, 28, 17, 30, 6, -48 },
  { 190, 38, 48, 35, 0, -48 },
  { 418, 32, 55, 32, 1, -51 },
  { 638, 48, 50, 53, 4, -49 },
  { 938, 40, 49, 40, 0, -48 },
  { 1183, 14, 17, 16, 6, -48 },
  { 1213, 24, 60, 19, 1, -49 },
  { 1393, 23, 60, 19, -5, -49 },
  { 1566, 28, 32, 30, 4, -52 },
  { 1678, 29, 33, 34, 3, -40 },
  { 1798, 17, 19, 17, -4, -10 },
  { 1839, 19, 10, 21, 1, -23 },
  { 1863, 12, 13, 17, 0, -12 },
  { 1883, 37, 50, 27, -4, -49 },
  { 2115, 30, 50, 32, 2, -49 },
  { 2303, 26, 48, 32, 6, -48 },
  { 2459, 33, 49, 32, -2, -49 },
  { 2662, 32, 50, 32, 0, -49 },
  { 2862, 34, 48, 32, -1, -48 },
  { 3066, 32, 49, 32, 1, -48 },
  { 3262, 32, 50, 32, 2, -49 },
  { 3462, 33, 48, 32, 2, -48 },
  { 3660, 32, 50, 32, 1, -49 },
  { 3860, 31, 50, 32, 1, -49 },
  { 4054, 18, 39, 18, 0, -38 },
  { 4142, 22, 47, 18, -4, -38 },
  { 4272, 29, 34, 34, 3, -41 },
  { 4396, 29, 23, 34, 3, -35 },
  { 4480, 29, 34, 34, 3, -41 },
  { 4604, 26, 50, 25, 2, -49 },
  { 4767, 46, 53, 47, 1, -48 },
  { 5072, 36, 48, 36, -4, -48 },
  { 5288, 36, 48, 35, 0, -48 },
  { 5504, 34, 50, 32, 2, -49 },
  { 5717, 36, 48, 36, 0, -48 },
  { 5933, 31, 48, 28, 0, -48 },
  { 6119, 31, 48, 27, 0, -48 },
  { 6305, 37, 50, 37, 2, -49 },
  { 6537, 40, 48, 38, 0, -48 },
  { 6777, 32, 48, 25, -2, -48 },
  { 6969, 32, 63, 18, -11, -48 },
  { 7221, 41, 48, 34, 0, -48 },
  { 7467, 24, 48, 27, 0, -48 },
  { 7611, 52, 48, 50, 0, -48 },
  { 7923, 43, 48, 41, 0, -48 },
  { 8181, 36, 50, 38, 2, -49 },
  { 8406, 34, 48, 32, 0, -48 },
  { 8610, 36, 60, 38, 2, -49 },
  { 8880, 35, 48, 34, 0, -48 },
  { 9090, 34, 50, 29, -1, -49 },
  { 9303, 29, 48, 29, 5, -48 },
  { 9477, 37, 49, 36, 2, -48 },
  { 9704, 35, 48, 35, 6, -48 },
  { 9914, 52, 48, 50, 4, -48 },
  { 10226, 42, 48, 34, -4, -48 },
  { 10478, 33, 48, 33, 6, -48 },
  { 10676, 37, 48, 29, -3, -48 },
  { 10898, 28, 60, 19, -3, -49 },
  { 11108, 15, 50, 27, 7, -49 },
  { 11202, 28, 60, 19, -5, -49 },
  { 11412, 32, 32, 31, -1, -48 },
  { 11540, 28, 8, 26, -7, 4 },
  { 11568, 14, 10, 22, 10, -51 },
  { 11586, 33, 39, 33, 1, -38 },
  { 11747, 33, 52, 33, -1, -51 },
  { 11962, 28, 39, 27, 1, -38 },
  { 12099, 36, 52, 33, 1, -51 },
  { 12333, 29, 39, 31, 1, -38 },
  { 12475, 35, 67, 21, -7, -51 },
  { 12769, 36, 54, 33, -2, -38 },
  { 13012, 33, 51, 33, -1, -51 },
  { 13223, 21, 52, 17, -1, -52 },
  { 13360, 28, 68, 17, -8, -52 },
  { 13598, 37, 51, 32, -1, -51 },
  { 13834, 22, 51, 17, -1, -51 },
  { 13975, 49, 38, 49, -1, -38 },
  { 14208, 33, 38, 33, -1, -38 },
  { 14365, 30, 39, 32, 1, -38 },
  { 14512, 36, 54, 33, -4, -38 },
  { 14755, 33, 54, 33, 1, -38 },
  { 14978, 28, 38, 24, -1, -38 },
  { 15111, 27, 39, 26, 0, -38 },
  { 15243, 22, 45, 23, 3, -44 },
  { 15367, 33, 38, 33, 1, -37 },
  { 15524, 30, 37, 31, 4, -37 },
  { 15663, 46, 37, 45, 3, -37 },
  { 15876, 38, 37, 31, -4, -37 },
  { 16052, 38, 53, 31, -4, -37 },
  { 16304, 31, 37, 26, -3, -37 },
  { 16448, 28, 59, 23, 0, -48 },
  { 16655, 10, 67, 26, 8, -52 },
  { 16739, 27, 59, 23, -4, -48 },
  { 16939, 29, 13, 34, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC67PT7B_H_
