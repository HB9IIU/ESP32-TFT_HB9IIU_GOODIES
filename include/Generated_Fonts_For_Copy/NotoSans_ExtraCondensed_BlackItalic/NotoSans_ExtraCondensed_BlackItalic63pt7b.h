#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFC, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xF1, 0xFF,
  0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3,
  0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0x9F, 0x80, 0x7F, 0xCE,
  0x1C, 0x01, 0xFF, 0x38, 0x10, 0x07, 0xFD, 0xE0, 0x00, 0x1F, 0xF7, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xBF, 0xE0, 0x40, 0x0E, 0x7F, 0x80, 0x80, 0x39, 0xFE,
  0x03, 0x80, 0xE7, 0xF8, 0x1F, 0x07, 0xBF, 0xE0, 0x7F, 0x1D, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x3F, 0xC0, 0xF0, 0x3F, 0xC7, 0xF9,
  0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0xE1, 0xFE, 0xFF, 0x3F,
  0xC7, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x3F,
  0xEF, 0xE1, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0xC3, 0xFE, 0x1F, 0xE7, 0xF8,
  0xFF, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF,
  0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xEF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x04, 0x0F, 0xF8, 0x01, 0x83, 0xFE, 0x00, 0x78, 0xFF, 0x00, 0x3F,
  0x3F, 0xC0, 0xCF, 0xFF, 0xF1, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xC0,
  0xFF, 0x9F, 0xF8, 0x1F, 0xE3, 0xFF, 0x03, 0xF0, 0xFF, 0x80, 0x7C, 0x3F,
  0x80, 0x0E, 0x07, 0xC0, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0x87, 0xFD, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF9, 0xFC, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF8,
  0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF,
  0x3F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF,
  0xCF, 0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xBF, 0xF0, 0x3F, 0x3F, 0xF0, 0x1E, 0x3F, 0xF0, 0x1C, 0x7F, 0xF0, 0x08,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x3E,
  0x07, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x18, 0x07, 0xFE, 0x00, 0x10,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xF0, 0x07, 0x01, 0xFF, 0xC0,
  0x18, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x08, 0x00, 0x1F, 0xFC, 0x20, 0x00, 0xFF, 0xF0, 0xF0, 0x07, 0xFF,
  0xC3, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xF0, 0x00,
  0x3F, 0xBF, 0xF0, 0x00, 0x7F, 0x7F, 0xF0, 0x00, 0xFF, 0x7F, 0xE0, 0x01,
  0xFE, 0x7F, 0xE0, 0x01, 0xFC, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x07,
  0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xEF, 0xFF,
  0xC0, 0x08, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x0F, 0xFE, 0x0C, 0x00,
  0x7F, 0xF8, 0x3C, 0x03, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7C, 0x00,
  0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x0F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE7, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF,
  0x81, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x07, 0xC3,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x70,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xC0, 0xFF,
  0xE1, 0x80, 0x3F, 0xE0, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFC, 0x7E, 0x03, 0xF8,
  0x3F, 0xFF, 0xC7, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF,
  0xFF, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF8, 0x3F, 0x87,
  0xE3, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x7F, 0x1F, 0xE0, 0xFE, 0x0F, 0xC7, 0xF1, 0xFE,
  0x0F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC1, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xE7, 0xFC, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0x80, 0xFE,
  0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x9F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x70,
  0x07, 0xFF, 0x80, 0x20, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x02, 0x00, 0x7F, 0xF8, 0x1E, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xE0, 0x1F, 0xFF, 0x00, 0x10, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x80, 0x3F, 0xEF, 0xF1, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xF9, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFE, 0xFF,
  0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0x7F, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFF,
  0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0xF9, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0x00,
  0x7F, 0xDF, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFD, 0xFF, 0x80, 0x3F, 0xF3,
  0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xBF,
  0xF0, 0x07, 0xFE, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE,
  0x07, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xDF, 0xFE, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC7,
  0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC0,
  0x70, 0x03, 0xFF, 0x80, 0x30, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x20, 0x01, 0xFF, 0xC0, 0x30, 0x01, 0xFF, 0xC0, 0x3C, 0x03, 0xFF,
  0xC0, 0x7F, 0x8F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF,
  0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF9, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0x3F, 0xF0, 0x07,
  0xFE, 0x7F, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xDF, 0xFC, 0x01,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF7, 0xFB, 0xFF, 0x00,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0x9F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF9,
  0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFB, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x1E, 0x07, 0xFF,
  0x01, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x10, 0x3F, 0xF8, 0x1C, 0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00,
  0xFF, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0xFF, 0xE0, 0x1C, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE6, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xCF, 0xF8,
  0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xCF, 0xFC, 0x00, 0x03, 0x83, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x02, 0x00, 0x07, 0xFE,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xF7, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFE, 0x7F, 0xF0, 0x07, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF9,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0xE0, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8,
  0x03, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x9F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x38, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x7F, 0xCF,
  0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x1C, 0x0F, 0xFE, 0x02, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x80, 0x1F, 0xFC, 0x60, 0x0F, 0xFC, 0x3E, 0x0F, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x8C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0x00,
  0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF,
  0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xCF, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFD, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xF0, 0x7F,
  0xE7, 0xFE, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF,
  0x9F, 0xF8, 0x3F, 0xE7, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xBF, 0xFF, 0xDF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFB, 0xFE, 0x03,
  0xFE, 0xFE, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFB, 0xFB, 0xFE, 0x01, 0xFE, 0xFE, 0x7F, 0x7F, 0xC0, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x21, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xE0, 0x01, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0xC0, 0x01, 0xFF, 0xC8, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 20, 46, 16, 0, -45 },
  { 116, 26, 16, 28, 6, -45 },
  { 168, 35, 45, 33, 0, -45 },
  { 365, 30, 52, 30, 1, -48 },
  { 560, 46, 47, 50, 3, -46 },
  { 831, 38, 47, 38, 0, -46 },
  { 1055, 13, 16, 15, 6, -45 },
  { 1081, 22, 56, 18, 1, -46 },
  { 1235, 22, 56, 18, -5, -46 },
  { 1389, 26, 30, 28, 4, -49 },
  { 1487, 27, 31, 32, 3, -38 },
  { 1592, 16, 18, 16, -4, -9 },
  { 1628, 18, 10, 19, 1, -22 },
  { 1651, 11, 12, 16, 0, -11 },
  { 1668, 35, 47, 25, -4, -46 },
  { 1874, 28, 47, 30, 2, -46 },
  { 2039, 24, 45, 30, 6, -45 },
  { 2174, 32, 46, 30, -2, -46 },
  { 2358, 30, 47, 30, 0, -46 },
  { 2535, 32, 45, 30, -1, -45 },
  { 2715, 30, 46, 30, 1, -45 },
  { 2888, 30, 47, 30, 2, -46 },
  { 3065, 31, 45, 30, 2, -45 },
  { 3240, 30, 47, 30, 1, -46 },
  { 3417, 29, 47, 30, 1, -46 },
  { 3588, 17, 36, 17, 0, -35 },
  { 3665, 21, 44, 17, -4, -35 },
  { 3781, 28, 31, 32, 2, -38 },
  { 3890, 27, 22, 32, 3, -33 },
  { 3965, 27, 31, 32, 3, -38 },
  { 4070, 25, 47, 24, 2, -46 },
  { 4217, 44, 51, 44, 1, -46 },
  { 4498, 34, 45, 34, -4, -45 },
  { 4690, 33, 45, 33, 0, -45 },
  { 4876, 32, 47, 30, 2, -46 },
  { 5064, 34, 45, 34, 0, -45 },
  { 5256, 30, 45, 26, 0, -45 },
  { 5425, 30, 45, 26, 0, -45 },
  { 5594, 34, 47, 35, 2, -46 },
  { 5794, 38, 45, 35, 0, -45 },
  { 6008, 30, 45, 24, -2, -45 },
  { 6177, 30, 59, 17, -10, -45 },
  { 6399, 39, 45, 32, 0, -45 },
  { 6619, 23, 45, 25, 0, -45 },
  { 6749, 49, 45, 47, 0, -45 },
  { 7025, 41, 45, 38, 0, -45 },
  { 7256, 34, 47, 36, 2, -46 },
  { 7456, 32, 45, 30, 0, -45 },
  { 7636, 34, 57, 36, 2, -46 },
  { 7879, 33, 45, 32, 0, -45 },
  { 8065, 32, 47, 27, -1, -46 },
  { 8253, 27, 45, 27, 5, -45 },
  { 8405, 35, 46, 34, 2, -45 },
  { 8607, 33, 45, 33, 6, -45 },
  { 8793, 49, 45, 47, 4, -45 },
  { 9069, 40, 45, 32, -4, -45 },
  { 9294, 31, 45, 31, 6, -45 },
  { 9469, 34, 45, 28, -2, -45 },
  { 9661, 26, 57, 18, -3, -46 },
  { 9847, 15, 47, 25, 6, -46 },
  { 9936, 26, 57, 18, -5, -46 },
  { 10122, 31, 30, 29, -1, -45 },
  { 10239, 26, 8, 24, -6, 4 },
  { 10265, 14, 10, 21, 9, -48 },
  { 10283, 31, 36, 31, 1, -35 },
  { 10423, 31, 49, 31, -1, -48 },
  { 10613, 26, 36, 25, 1, -35 },
  { 10730, 33, 49, 31, 1, -48 },
  { 10933, 28, 36, 29, 1, -35 },
  { 11059, 34, 63, 19, -7, -48 },
  { 11327, 34, 50, 31, -2, -35 },
  { 11540, 31, 48, 31, -1, -48 },
  { 11726, 20, 49, 16, -1, -49 },
  { 11849, 27, 64, 16, -8, -49 },
  { 12065, 35, 48, 30, -1, -48 },
  { 12275, 20, 48, 16, -1, -48 },
  { 12395, 46, 35, 46, -1, -35 },
  { 12597, 31, 35, 31, -1, -35 },
  { 12733, 28, 36, 30, 1, -35 },
  { 12859, 34, 50, 31, -4, -35 },
  { 13072, 31, 50, 31, 1, -35 },
  { 13266, 26, 35, 22, -1, -35 },
  { 13380, 25, 36, 24, 0, -35 },
  { 13493, 22, 43, 22, 2, -42 },
  { 13612, 31, 36, 31, 1, -35 },
  { 13752, 28, 35, 29, 4, -35 },
  { 13875, 43, 35, 43, 3, -35 },
  { 14064, 35, 35, 29, -3, -35 },
  { 14218, 36, 50, 29, -4, -35 },
  { 14443, 30, 35, 25, -3, -35 },
  { 14575, 27, 55, 22, 0, -45 },
  { 14761, 9, 63, 25, 8, -49 },
  { 14832, 25, 55, 22, -4, -45 },
  { 15004, 28, 12, 32, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC63PT7B_H_
