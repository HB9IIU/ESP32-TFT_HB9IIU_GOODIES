#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x62, 0xC0, 0x7F, 0xE0, 0x2D, 0x3C, 0xD7, 0x8E, 0xA0, 0x65, 0xEE,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x2A, 0x40, 0x76, 0xE0, 0xEA, 0x65, 0x60, 0x69, 0xE0, 0x6F, 0xA0, 0x78,
  0xE0, 0x7E, 0xE0, 0x69, 0x40, 0x6A, 0xE0, 0x75, 0xE0, 0xC8, 0xCA, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xE8, 0x40, 0x7F, 0xFE, 0x6F, 0xD0, 0x7E, 0xF0,
  0x72, 0x60, 0x76, 0xE0, 0x7A, 0x60, 0x7A, 0x40, 0x76, 0xF0, 0x7E, 0xAA,
  0x69, 0x60, 0x25, 0x2C, 0x7C, 0xCA, 0x6B, 0x5E, 0xBD, 0xA0, 0x5D, 0xAA,
  0x76, 0xF0, 0x77, 0x40, 0x76, 0xF6, 0x77, 0x50, 0x79, 0x60, 0xE9, 0x60,
  0x7A, 0xAE, 0xFA, 0x40, 0xED, 0xBD, 0xE0, 0x69, 0x50, 0xEA, 0x6B, 0x60,
  0x6A, 0x80, 0xF0, 0x5A, 0x80, 0x56, 0x80, 0xE0, 0x80, 0xF7, 0x00, 0x4B,
  0xDC, 0xF3, 0x00, 0x27, 0xDC, 0xFB, 0x00, 0x32, 0x64, 0x4C, 0xF7, 0x60,
  0x4B, 0xDC, 0x5A, 0x80, 0x25, 0x25, 0x80, 0x4A, 0xEE, 0x5A, 0x80, 0xFB,
  0xD0, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20, 0xE8, 0xDC, 0x7B,
  0xF7, 0x00, 0xBB, 0x00, 0xBF, 0xE0, 0xEB, 0x00, 0xB9, 0x40, 0xEB, 0x00,
  0x6A, 0x4C, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 2, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 1, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 2, 3, 2, 0, -3 },
  { 46, 2, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 4, 2, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 2, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 3, 0, -4 },
  { 72, 3, 4, 2, 0, -4 },
  { 74, 3, 5, 2, -1, -4 },
  { 76, 4, 4, 3, 0, -4 },
  { 78, 2, 4, 2, 0, -4 },
  { 79, 5, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 5, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 4, 4, 3, 0, -4 },
  { 98, 3, 4, 3, 1, -4 },
  { 100, 5, 4, 4, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 4, 3, 1, -4 },
  { 106, 3, 4, 3, 0, -4 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 1, 4, 2, 1, -4 },
  { 111, 2, 5, 2, 0, -4 },
  { 113, 3, 3, 3, 0, -4 },
  { 115, 3, 1, 2, -1, 0 },
  { 116, 1, 1, 2, 1, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 3, 2, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 4, 6, 2, -1, -5 },
  { 130, 3, 4, 3, 0, -3 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 2, 5, 2, 0, -5 },
  { 136, 3, 6, 2, -1, -5 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 2, 5, 2, 0, -5 },
  { 143, 4, 3, 4, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 4, 3, 0, -3 },
  { 151, 3, 4, 3, 0, -3 },
  { 153, 2, 3, 2, 0, -3 },
  { 154, 2, 3, 2, 0, -3 },
  { 155, 2, 4, 2, 0, -4 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 4, 3, 4, 0, -3 },
  { 162, 3, 3, 3, 0, -3 },
  { 164, 3, 4, 3, 0, -3 },
  { 166, 3, 3, 2, 0, -3 },
  { 168, 3, 5, 2, 0, -4 },
  { 170, 1, 6, 2, 1, -5 },
  { 171, 2, 5, 2, 0, -4 },
  { 173, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC6PT7B_H_
