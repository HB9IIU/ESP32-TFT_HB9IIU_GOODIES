#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7E, 0xFD,
  0xFB, 0xF7, 0xCF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0x3E, 0x7C,
  0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFF, 0xF8, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xF1, 0xE0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xDC, 0x1F, 0x62, 0x0F, 0xA0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x18, 0x7F, 0x0E, 0x2F, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x3F, 0xC0, 0xF0, 0x3F, 0xE1, 0xE0, 0x7D,
  0xE1, 0xE0, 0x79, 0xE3, 0xC0, 0xF9, 0xE7, 0xC0, 0xF3, 0xE7, 0x80, 0xF3,
  0xCF, 0x80, 0xF3, 0xCF, 0x00, 0xF3, 0xDE, 0x3C, 0xF7, 0x9E, 0x7E, 0xFF,
  0xBC, 0xFF, 0xFF, 0x3D, 0xFF, 0x7E, 0x79, 0xEF, 0x18, 0xFB, 0xCF, 0x00,
  0xF3, 0xCF, 0x01, 0xF3, 0xCF, 0x01, 0xE7, 0xCF, 0x03, 0xC7, 0x9F, 0x03,
  0xC7, 0x9E, 0x07, 0x87, 0xFE, 0x0F, 0x83, 0xFC, 0x0F, 0x03, 0xF8, 0x1F,
  0x01, 0xF0, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF3, 0xF0, 0xFF, 0x3F,
  0x0F, 0xFD, 0xF8, 0xFF, 0xEF, 0x8F, 0xFF, 0xFC, 0x7C, 0xFF, 0xC7, 0xE7,
  0xFE, 0x3F, 0x1F, 0xE1, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE0, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0xBE, 0x7C, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x84, 0x3C, 0x0C, 0xF0, 0x7B, 0xCD, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x0F, 0xFC, 0x7F, 0x03, 0xFE, 0x1F, 0xFC, 0x3D,
  0xF8, 0x73, 0xC0, 0x8E, 0x00, 0x20, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x00,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x40, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xCF, 0x9F, 0x9F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF8, 0xFB, 0xE3, 0xF7, 0xC7,
  0xEF, 0x8F, 0xFF, 0x1F, 0x7E, 0x7E, 0xFC, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7,
  0xCF, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xFE,
  0x7B, 0xE3, 0xBF, 0x09, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1C, 0x7E, 0x04, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x03, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0x3F, 0x04, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x80, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0xFC, 0x3C, 0xFC,
  0x3C, 0xFC, 0x78, 0xF9, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x11, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x81, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xE1, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFE, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x3F, 0x3E, 0x0F, 0xBF, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x20, 0x01,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xBF, 0x1F, 0x9F, 0x1F,
  0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFC, 0x7F, 0xE0, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x07,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xF9, 0xFF, 0xCF,
  0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x7F,
  0x8F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9C, 0xFC, 0x83, 0xE0, 0x1F, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC1, 0x07, 0x8F, 0x1F,
  0xEF, 0x3C, 0x7F, 0xDE, 0x79, 0xFF, 0xBD, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C,
  0xF7, 0x3C, 0x79, 0xFE, 0x78, 0xF3, 0xBC, 0xF3, 0xC7, 0x79, 0xC7, 0x9E,
  0xE7, 0x8F, 0x39, 0xC7, 0xBE, 0xF3, 0x8F, 0xFF, 0xC7, 0x1F, 0xBF, 0x0F,
  0x1E, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C,
  0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83,
  0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xDF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x9F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0x70,
  0x7E, 0x08, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC2, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1,
  0xF9, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xCF, 0x07, 0xF0, 0x21, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x3F, 0xC7, 0xE7, 0xF8, 0xFC, 0xFF, 0x3F,
  0x3F, 0xC7, 0xE7, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7F,
  0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFC, 0x3E, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x9F, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x07, 0xE3, 0xF8,
  0x3E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xCF,
  0xC0, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xEF,
  0xFC, 0x1F, 0xFD, 0xEF, 0x83, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0x7E, 0x0F,
  0xBF, 0xEF, 0x81, 0xF7, 0xFD, 0xF0, 0x7E, 0xFF, 0x3E, 0x0F, 0xDF, 0xEF,
  0xC1, 0xF3, 0xF9, 0xF8, 0x3E, 0x7F, 0x3E, 0x07, 0xCF, 0xC7, 0xC1, 0xF9,
  0xF9, 0xF8, 0x3F, 0x3F, 0x3F, 0x07, 0xC7, 0xC7, 0xE0, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F,
  0xC7, 0xE0, 0xFF, 0x1F, 0x87, 0xFE, 0x7C, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7,
  0xC1, 0xFF, 0xBF, 0x0F, 0xFE, 0xF8, 0x3E, 0xFF, 0xE0, 0xF9, 0xFF, 0x83,
  0xE7, 0xFE, 0x0F, 0x9F, 0xF8, 0x7E, 0x7F, 0xC1, 0xF9, 0xFF, 0x07, 0xC3,
  0xFC, 0x1F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0x83, 0xF8,
  0x3E, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xF8, 0x3E, 0x3F, 0x07,
  0xEF, 0xE0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFD, 0xFC, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC,
  0x7E, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xF8,
  0x3E, 0x3F, 0x07, 0xEF, 0xE0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x7E, 0x7F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xFC, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFC, 0x30, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x84, 0x07, 0xE1, 0xC3, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xC1, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x1F, 0x0F, 0xDF, 0x87, 0xC3, 0xF7, 0xE3, 0xF0, 0xF9, 0xF0, 0xFC, 0x7E,
  0x7C, 0x3F, 0x1F, 0x9F, 0x1F, 0xC7, 0xC7, 0xC7, 0xF3, 0xF1, 0xF3, 0xFC,
  0xFC, 0x7C, 0xFF, 0x7E, 0x1F, 0x7F, 0xDF, 0x87, 0xDF, 0xF7, 0xC1, 0xF7,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x81,
  0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0xFE, 0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC3, 0xF7, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xF8, 0xF8, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xDE, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0,
  0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFC, 0xF9, 0xF9, 0xF3, 0xE0, 0x03, 0xCF, 0x87, 0xF7, 0xC3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xFB,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xBC, 0x0F, 0x9E, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0xBC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xF3, 0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xF8,
  0x47, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE1, 0x0F, 0xDC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xCF, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x7D, 0xF9,
  0xF7, 0xC7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC3, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0xFD, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F,
  0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xF7, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x20, 0x3E, 0x0F, 0x3F, 0x83, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xBC, 0x1F, 0x7E,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF3, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC,
  0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x3E, 0x3E, 0x1F, 0x7F, 0x7F,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF8, 0x1F, 0x3C, 0x1F, 0x7E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC,
  0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xFF, 0xEF, 0xCF, 0xDF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFB,
  0xE1, 0xF7, 0xC7, 0xEF, 0x8F, 0xDF, 0x1F, 0x3F, 0x7E, 0x7F, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xCF, 0x01, 0xF7, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7,
  0xE1, 0xFB, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xBF, 0x03, 0xEF, 0x81,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xCF, 0x83, 0xF7, 0xC3, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x3C, 0x7D, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC3, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0x30, 0xF8,
  0x43, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF2, 0x0F, 0xCF, 0x7E, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0x03, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x1F, 0xF3, 0xFF, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE3, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFD, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x3F,
  0x1F, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8,
  0xFC, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF8, 0x7C,
  0xF0, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xF7, 0xE7, 0xEF, 0xCF, 0x9F, 0x1F,
  0x3E, 0x7E, 0x7C, 0xF8, 0xFB, 0xF0, 0xF7, 0xC1, 0xEF, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0xFE, 0x7F, 0xF1, 0xF8, 0xFB, 0xE3, 0xF1, 0xF7, 0xCF, 0xE7,
  0xEF, 0x9F, 0xCF, 0x9F, 0x7F, 0x9F, 0x3E, 0xFF, 0x7C, 0x7D, 0xFE, 0xF8,
  0xFF, 0xBD, 0xF1, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x87, 0xF9, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE,
  0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xF8,
  0xF8, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E,
  0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x00,
  0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x07,
  0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFC, 0x07,
  0xE0, 0x07, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 19, 24, 18, 0, -24 },
  { 107, 17, 28, 16, 0, -26 },
  { 167, 24, 25, 27, 2, -25 },
  { 242, 21, 25, 20, 0, -25 },
  { 308, 7, 9, 8, 3, -24 },
  { 316, 13, 30, 10, 0, -25 },
  { 365, 12, 30, 10, -3, -25 },
  { 410, 14, 16, 15, 2, -26 },
  { 438, 15, 16, 17, 1, -20 },
  { 468, 9, 10, 9, -2, -5 },
  { 480, 10, 5, 10, 0, -12 },
  { 487, 6, 6, 9, 0, -6 },
  { 492, 19, 25, 14, -2, -25 },
  { 552, 15, 25, 16, 1, -25 },
  { 599, 13, 24, 16, 3, -24 },
  { 638, 17, 25, 16, -1, -25 },
  { 692, 16, 25, 16, 0, -25 },
  { 742, 16, 24, 16, 0, -24 },
  { 790, 16, 24, 16, 1, -24 },
  { 838, 16, 25, 16, 1, -25 },
  { 888, 17, 24, 16, 1, -24 },
  { 939, 17, 25, 16, 0, -25 },
  { 993, 16, 25, 16, 0, -25 },
  { 1043, 9, 19, 9, 0, -19 },
  { 1065, 11, 24, 9, -2, -19 },
  { 1098, 15, 17, 17, 1, -21 },
  { 1130, 15, 12, 17, 1, -18 },
  { 1153, 15, 17, 17, 1, -21 },
  { 1185, 13, 25, 13, 1, -25 },
  { 1226, 23, 28, 24, 1, -25 },
  { 1307, 18, 24, 18, -2, -24 },
  { 1361, 18, 24, 18, 0, -24 },
  { 1415, 17, 25, 16, 1, -25 },
  { 1469, 19, 24, 18, 0, -24 },
  { 1526, 16, 24, 14, 0, -24 },
  { 1574, 16, 24, 14, 0, -24 },
  { 1622, 19, 25, 19, 1, -25 },
  { 1682, 21, 24, 19, 0, -24 },
  { 1745, 16, 24, 13, -1, -24 },
  { 1793, 16, 32, 9, -5, -24 },
  { 1857, 21, 24, 17, 0, -24 },
  { 1920, 12, 24, 14, 0, -24 },
  { 1956, 27, 24, 25, 0, -24 },
  { 2037, 22, 24, 21, 0, -24 },
  { 2103, 19, 25, 20, 1, -25 },
  { 2163, 17, 24, 16, 0, -24 },
  { 2214, 19, 31, 20, 1, -25 },
  { 2288, 18, 24, 17, 0, -24 },
  { 2342, 18, 25, 15, -1, -25 },
  { 2399, 15, 24, 15, 2, -24 },
  { 2444, 19, 24, 19, 1, -24 },
  { 2501, 18, 24, 18, 3, -24 },
  { 2555, 26, 24, 25, 2, -24 },
  { 2633, 22, 24, 17, -2, -24 },
  { 2699, 17, 24, 17, 3, -24 },
  { 2750, 18, 24, 15, -1, -24 },
  { 2804, 15, 31, 10, -2, -25 },
  { 2863, 8, 25, 14, 3, -25 },
  { 2888, 15, 31, 10, -3, -25 },
  { 2947, 17, 16, 16, -1, -24 },
  { 2981, 14, 4, 13, -3, 2 },
  { 2988, 7, 5, 11, 5, -26 },
  { 2993, 17, 19, 17, 0, -19 },
  { 3034, 16, 26, 17, 0, -26 },
  { 3086, 14, 19, 14, 1, -19 },
  { 3120, 19, 26, 17, 0, -26 },
  { 3182, 14, 19, 16, 1, -19 },
  { 3216, 18, 34, 11, -4, -26 },
  { 3293, 18, 27, 17, -1, -19 },
  { 3354, 16, 26, 17, 0, -26 },
  { 3406, 10, 26, 9, 0, -26 },
  { 3439, 14, 34, 9, -4, -26 },
  { 3499, 18, 26, 16, 0, -26 },
  { 3558, 11, 26, 9, 0, -26 },
  { 3594, 24, 19, 25, 0, -19 },
  { 3651, 16, 19, 17, 0, -19 },
  { 3689, 15, 19, 16, 1, -19 },
  { 3725, 18, 27, 17, -2, -19 },
  { 3786, 17, 27, 17, 0, -19 },
  { 3844, 14, 19, 12, 0, -19 },
  { 3878, 14, 19, 13, 0, -19 },
  { 3912, 12, 23, 12, 1, -23 },
  { 3947, 16, 19, 17, 1, -19 },
  { 3985, 15, 19, 16, 2, -19 },
  { 4021, 23, 19, 23, 2, -19 },
  { 4076, 19, 19, 16, -2, -19 },
  { 4122, 19, 27, 16, -2, -19 },
  { 4187, 15, 19, 13, -1, -19 },
  { 4223, 14, 29, 12, 0, -24 },
  { 4274, 5, 34, 13, 4, -26 },
  { 4296, 14, 29, 12, -2, -24 },
  { 4347, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC34PT7B_H_
