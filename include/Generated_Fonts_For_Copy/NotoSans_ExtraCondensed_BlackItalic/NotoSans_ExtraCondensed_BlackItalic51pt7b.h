#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0x10, 0x00, 0x7F, 0xCF, 0xFB, 0xFE, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF,
  0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC,
  0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC2, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF6,
  0x38, 0x0F, 0xEE, 0x08, 0x0F, 0xEE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x37, 0xF0, 0x40, 0x77, 0xF0, 0x60, 0x77,
  0xF0, 0x70, 0x77, 0xF0, 0x7C, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xC0, 0x1F, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0x3F,
  0x03, 0xF0, 0x07, 0xF3, 0xF0, 0x7F, 0x00, 0x7E, 0x3F, 0x07, 0xE0, 0x07,
  0xE3, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF1, 0xF8,
  0x00, 0xFC, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x7F, 0x00, 0x0F, 0xCF, 0xE7, 0xE1, 0xFC, 0xFC, 0xFC, 0xFC, 0x7F, 0xEF,
  0xFF, 0xCF, 0xCF, 0xFE, 0xFF, 0xF9, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0x9F,
  0xFF, 0x7F, 0xF3, 0xF3, 0xFB, 0xF3, 0xFC, 0x7F, 0x3F, 0x3F, 0x1F, 0x07,
  0xE7, 0xE3, 0xF0, 0x00, 0xFE, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0,
  0x01, 0xF8, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0xFC, 0x7E, 0x00, 0xFE,
  0x0F, 0xCF, 0xE0, 0x0F, 0xC0, 0xFE, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0x80, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x02,
  0x03, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0x3F, 0xE0,
  0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xEF, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x83, 0xFE,
  0x1F, 0xFF, 0x07, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB,
  0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xDF,
  0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x10, 0x7E, 0x00, 0xF1, 0xF8, 0x03, 0xF7, 0xE1, 0x8F, 0xFF,
  0xBE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xE7, 0xF8, 0x0F, 0x0F,
  0xC0, 0x1C, 0x3C, 0x00, 0x20, 0x60, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F,
  0xCF, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF,
  0xF0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0xBF, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFF,
  0x3F, 0xC3, 0xFD, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0x7F, 0x83,
  0xE7, 0xF8, 0x1C, 0x7F, 0x80, 0x8F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xF0,
  0xFF, 0x80, 0x70, 0x7F, 0xC0, 0x30, 0x3F, 0xE0, 0x10, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0x01, 0xC0, 0xFF, 0x01, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x80, 0x0F, 0xF8, 0xE0, 0x3F, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xE0, 0x0F, 0xDF, 0xF0, 0x07, 0xEF,
  0xF0, 0x07, 0xE7, 0xF8, 0x07, 0xE3, 0xFC, 0x03, 0xF3, 0xFE, 0x03, 0xF1,
  0xFF, 0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x80, 0x3F, 0xF0, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x04, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xCF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x9F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xCF,
  0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F,
  0xE3, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE7, 0xFC,
  0x3F, 0xCF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xE7, 0xFE, 0x7F, 0xCF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x03, 0xCF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7E, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFB, 0xFF, 0x1C, 0x1F, 0xF1, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xDF, 0x87, 0xE1, 0xFF, 0xF1, 0xF0,
  0xFC, 0x7F, 0xFE, 0x3E, 0x3F, 0x1F, 0xFF, 0xC7, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF9, 0xF8, 0xFC, 0x3E, 0x1F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xC7, 0xE1,
  0xF8, 0xFD, 0xF8, 0xFC, 0x3F, 0x1F, 0xBF, 0x1F, 0x07, 0xC3, 0xE7, 0xC7,
  0xE1, 0xF8, 0x7C, 0xF8, 0xFC, 0x3F, 0x1F, 0xBF, 0x1F, 0x87, 0xE3, 0xE7,
  0xE3, 0xF1, 0xF8, 0x7C, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xE3,
  0xE3, 0xF1, 0xFF, 0xFF, 0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0x0F, 0xC7, 0xFE,
  0xFF, 0xC1, 0xF8, 0x7F, 0x9F, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC,
  0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xFC,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x0C, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x04, 0x07, 0xFE, 0x0E, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC7, 0xFE, 0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC3, 0xFF, 0x03,
  0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFE, 0x03, 0x00, 0xFF, 0xC0, 0x10, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0x87, 0xFC, 0x7F, 0xF8, 0x7F, 0xC7,
  0xFF, 0x8F, 0xF8, 0x7F, 0xF0, 0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0xFF, 0xF0,
  0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x43, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFE, 0x3F,
  0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xEF, 0xEF, 0xF0, 0x1F, 0xEF, 0xEF, 0xEF, 0xF0, 0x1F, 0xEF,
  0xEF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xDF, 0xE0, 0x1F, 0xEF, 0xFF, 0xDF,
  0xE0, 0x1F, 0xEF, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xFF, 0x9F, 0xE0, 0x3F,
  0xCF, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xFE,
  0x3F, 0xC0, 0x3F, 0xCF, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xFE, 0x7F, 0xC0,
  0x7F, 0x8F, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x07, 0xF8,
  0x0F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE1, 0xFE,
  0x03, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFC, 0x7F,
  0x80, 0x7F, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xCF,
  0xF0, 0x1F, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xF7, 0xF8, 0x07, 0xF3, 0xFB,
  0xFC, 0x07, 0xF9, 0xFD, 0xFE, 0x03, 0xFC, 0xFE, 0xFF, 0x01, 0xFE, 0x7F,
  0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xC0, 0x7F, 0x87,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0xF0, 0x0F, 0xF0,
  0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0xFC, 0x07, 0xF8, 0x3F, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE7, 0xFE, 0x0F, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF8, 0x0F,
  0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0,
  0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF,
  0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC,
  0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x1E,
  0x01, 0xFF, 0x01, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x04, 0x00, 0xFF, 0x80, 0x80,
  0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07,
  0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7,
  0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x03, 0xFE,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0x1F, 0xF0, 0x7F,
  0x87, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF,
  0x3F, 0xE0, 0x7F, 0x8F, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x7E, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F,
  0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xCF, 0xF8, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x30, 0x00, 0x80, 0xFE,
  0x3F, 0x80, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0xFF, 0x83, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xF8, 0x0F, 0xF9, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x8E, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0x7F, 0xC1, 0xFF, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xF7, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xF7, 0xFF,
  0x03, 0xFB, 0xFF, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x38, 0x3F, 0xE0, 0x41, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x10, 0x7F, 0xC1, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x01, 0xC3, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xEF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0xFE, 0x00, 0xFF, 0x9F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0xE1, 0xFC, 0xFF, 0x07, 0xF7,
  0xFC, 0x3F, 0xDF, 0xE7, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0x0F, 0xF8, 0x3C, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x88, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0xF3,
  0xF8, 0x03, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x0F, 0xF8, 0xFF,
  0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x02, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x1F, 0xF0, 0x18, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0E, 0x00,
  0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x1F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xF9, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x1F, 0xCF, 0xF0, 0x7F, 0x00, 0xFE,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xCF, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x87, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFC, 0xFF, 0x00, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x3F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF9, 0xFE, 0x3F, 0xE3,
  0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF7, 0xF8, 0x3F,
  0xCF, 0xF0, 0x7F, 0xBF, 0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFD,
  0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F,
  0xE3, 0xFE, 0x3F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFB, 0xFF,
  0x00, 0x7F, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFE, 0x7E, 0x00, 0x7F, 0x83, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC,
  0x03, 0xF9, 0xFE, 0x00, 0x21, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE7, 0xE0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x38, 0x1F,
  0xE0, 0x40, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x88, 0x07, 0xF8, 0x60, 0x7F, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFB, 0xF8,
  0x07, 0xF1, 0xFC, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF,
  0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFB, 0xFC, 0x7F, 0xF1, 0xFE, 0xFF, 0x1F, 0xFC,
  0xFF, 0xBF, 0xCF, 0xFE, 0x3F, 0xCF, 0xF3, 0xFF, 0x8F, 0xF3, 0xFC, 0xFF,
  0xE7, 0xF8, 0xFF, 0x7F, 0xF9, 0xFE, 0x3F, 0xDF, 0xFE, 0x7F, 0x0F, 0xF7,
  0xFF, 0xBF, 0xC3, 0xFB, 0xF7, 0xEF, 0xF0, 0xFE, 0xFD, 0xFB, 0xF8, 0x3F,
  0xBF, 0x7F, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xC0,
  0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x8F, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x47, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x0F,
  0x00, 0x02, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x80, 0x1F,
  0xF9, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 37, 13, 0, -36 },
  { 75, 21, 13, 23, 5, -36 },
  { 110, 29, 36, 27, 0, -36 },
  { 241, 24, 42, 24, 1, -39 },
  { 367, 36, 37, 40, 3, -37 },
  { 534, 31, 38, 31, 0, -37 },
  { 682, 10, 13, 12, 5, -36 },
  { 699, 18, 45, 14, 1, -37 },
  { 801, 18, 45, 14, -4, -37 },
  { 903, 22, 24, 23, 3, -39 },
  { 969, 22, 24, 26, 2, -30 },
  { 1035, 13, 14, 13, -3, -7 },
  { 1058, 15, 8, 16, 0, -18 },
  { 1073, 9, 10, 13, 0, -9 },
  { 1085, 28, 38, 20, -3, -37 },
  { 1218, 22, 38, 24, 2, -37 },
  { 1323, 20, 36, 24, 4, -36 },
  { 1413, 25, 37, 24, -1, -37 },
  { 1529, 24, 38, 24, 0, -37 },
  { 1643, 25, 36, 24, 0, -36 },
  { 1756, 24, 37, 24, 1, -36 },
  { 1867, 24, 38, 24, 2, -37 },
  { 1981, 26, 36, 24, 1, -36 },
  { 2098, 25, 38, 24, 0, -37 },
  { 2217, 23, 38, 24, 1, -37 },
  { 2327, 14, 30, 14, 0, -29 },
  { 2380, 17, 36, 14, -3, -29 },
  { 2457, 22, 25, 26, 2, -31 },
  { 2526, 22, 18, 26, 2, -27 },
  { 2576, 23, 25, 26, 2, -31 },
  { 2648, 20, 38, 19, 2, -37 },
  { 2743, 35, 41, 36, 1, -37 },
  { 2923, 27, 37, 27, -3, -37 },
  { 3048, 27, 36, 26, 0, -36 },
  { 3170, 25, 38, 24, 2, -37 },
  { 3289, 28, 36, 28, 0, -36 },
  { 3415, 24, 36, 21, 0, -36 },
  { 3523, 24, 36, 21, 0, -36 },
  { 3631, 28, 38, 28, 2, -37 },
  { 3764, 31, 36, 29, 0, -36 },
  { 3904, 25, 36, 19, -2, -36 },
  { 4017, 24, 47, 14, -8, -36 },
  { 4158, 31, 36, 26, 0, -36 },
  { 4298, 18, 36, 20, 0, -36 },
  { 4379, 40, 36, 38, 0, -36 },
  { 4559, 33, 36, 31, 0, -36 },
  { 4708, 27, 38, 29, 2, -37 },
  { 4837, 26, 36, 25, 0, -36 },
  { 4954, 27, 46, 29, 2, -37 },
  { 5110, 26, 36, 26, 0, -36 },
  { 5227, 26, 38, 22, -1, -37 },
  { 5351, 22, 36, 22, 4, -36 },
  { 5450, 28, 37, 28, 2, -36 },
  { 5580, 26, 36, 26, 5, -36 },
  { 5697, 40, 36, 38, 3, -36 },
  { 5877, 32, 36, 26, -3, -36 },
  { 6021, 25, 36, 25, 5, -36 },
  { 6134, 28, 36, 22, -2, -36 },
  { 6260, 22, 46, 15, -3, -37 },
  { 6387, 12, 38, 20, 5, -37 },
  { 6444, 21, 46, 15, -4, -37 },
  { 6565, 25, 24, 24, -1, -36 },
  { 6640, 21, 6, 20, -5, 3 },
  { 6656, 11, 8, 17, 7, -39 },
  { 6667, 25, 30, 25, 1, -29 },
  { 6761, 25, 40, 25, -1, -39 },
  { 6886, 21, 30, 20, 1, -29 },
  { 6965, 27, 40, 25, 1, -39 },
  { 7100, 22, 30, 24, 1, -29 },
  { 7183, 28, 51, 16, -6, -39 },
  { 7362, 27, 41, 25, -1, -29 },
  { 7501, 25, 39, 25, -1, -39 },
  { 7623, 16, 40, 13, -1, -40 },
  { 7703, 21, 52, 13, -6, -40 },
  { 7840, 29, 39, 25, -1, -39 },
  { 7982, 17, 39, 13, -1, -39 },
  { 8065, 37, 29, 37, -1, -29 },
  { 8200, 25, 29, 25, -1, -29 },
  { 8291, 23, 30, 24, 1, -29 },
  { 8378, 27, 41, 25, -3, -29 },
  { 8517, 25, 41, 25, 1, -29 },
  { 8646, 22, 29, 18, -1, -29 },
  { 8726, 21, 30, 20, 0, -29 },
  { 8805, 17, 35, 17, 2, -34 },
  { 8880, 25, 29, 25, 1, -28 },
  { 8971, 23, 28, 23, 3, -28 },
  { 9052, 34, 28, 35, 3, -28 },
  { 9171, 29, 28, 23, -3, -28 },
  { 9273, 29, 40, 23, -3, -28 },
  { 9418, 24, 28, 20, -2, -28 },
  { 9502, 21, 44, 18, 0, -36 },
  { 9618, 8, 51, 20, 6, -39 },
  { 9669, 20, 44, 18, -3, -36 },
  { 9779, 23, 10, 26, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC51PT7B_H_
