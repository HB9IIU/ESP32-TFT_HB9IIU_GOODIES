#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x10, 0x00, 0x3F,
  0x9F, 0xE7, 0xF3, 0xF9, 0xFE, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x7F, 0x1F, 0xCF, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xC7,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x1F, 0x1F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0xCF, 0x07, 0xF6, 0x10, 0x3F,
  0x30, 0x01, 0xFD, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x08, 0x19, 0xF8, 0x60, 0xDF, 0xC3,
  0xC6, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFC,
  0x01, 0xFF, 0xE0, 0x7C, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0xFD, 0xF8, 0x3E,
  0x00, 0x7C, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x1F,
  0x80, 0x1F, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x8F, 0x80, 0x07, 0xC7, 0xCF,
  0xC0, 0x07, 0xE7, 0xE7, 0xC3, 0xC3, 0xF3, 0xE7, 0xE7, 0xF8, 0xFB, 0xF3,
  0xE7, 0xFE, 0x7F, 0xF3, 0xF7, 0xFF, 0x3F, 0xFB, 0xF3, 0xFF, 0x8F, 0xF9,
  0xF3, 0xF7, 0xE7, 0xF9, 0xF9, 0xF3, 0xF0, 0x60, 0xF9, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0xFC, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x3E, 0x00,
  0x7E, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x9F, 0x80, 0x3F, 0x0F, 0xCF, 0x80,
  0x1F, 0x07, 0xE7, 0xC0, 0x1F, 0x83, 0xFF, 0xE0, 0x0F, 0x80, 0xFF, 0xE0,
  0x0F, 0xC0, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x07, 0xFF, 0x1F, 0xE1, 0xFF,
  0xF3, 0xF8, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xF8,
  0xFF, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xC7, 0xF8, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFC, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xEF,
  0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0x9F, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x02, 0x1F, 0x80, 0x73, 0xF0, 0x1F, 0xFE, 0x33, 0xFF, 0xBE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x78, 0xFC,
  0x06, 0x1E, 0x00, 0x41, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFF, 0x7F, 0xF8, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x30, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF8,
  0x7F, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF1, 0xFE, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x8F, 0xDF, 0xC3, 0xDF, 0xE1,
  0xCF, 0xE0, 0x47, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFC, 0xFF, 0x01, 0xC3, 0xFC, 0x06, 0x0F, 0xF0, 0x10, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xE0, 0xFF, 0x02, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE2, 0x00, 0xFF, 0x0E, 0x07,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7D, 0xFE, 0x03,
  0xE7, 0xF8, 0x1F, 0x9F, 0xC0, 0x7C, 0x7F, 0x03, 0xE1, 0xFC, 0x1F, 0x8F,
  0xF2, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x63, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x80, 0x7F, 0x87, 0x07, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0xFE, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFE,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xF3,
  0xFC, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0xFF, 0x3F, 0x8F, 0xF3, 0xFD, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xF9, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x81, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x7C,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x78, 0xFF, 0x18, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x7C, 0x1F, 0x87, 0xFC, 0x7C, 0x3E, 0x3F, 0xFC, 0xF8, 0xF8,
  0xFF, 0xF9, 0xF1, 0xF1, 0xFF, 0xF3, 0xE7, 0xC7, 0xE7, 0xC7, 0xCF, 0x9F,
  0x8F, 0x8F, 0xBE, 0x3E, 0x1F, 0x1F, 0x7C, 0x7C, 0x7E, 0x3C, 0xF9, 0xF8,
  0xF8, 0xF9, 0xE3, 0xE1, 0xF1, 0xF7, 0xC7, 0xC3, 0xE3, 0xEF, 0x8F, 0x8F,
  0xC7, 0x9F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x7E, 0x3C, 0x7C, 0x7F, 0xFD,
  0xF8, 0xF8, 0xFF, 0xFF, 0xE1, 0xF1, 0xFF, 0xFF, 0x83, 0xE1, 0xFC, 0xFE,
  0x07, 0xC1, 0xE0, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xCF, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x8F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFE, 0x18, 0x1F, 0xF0,
  0x20, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x04, 0x0F,
  0xF8, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0x3C, 0x1F, 0xF0, 0x08, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x9F, 0xFC, 0x7F, 0x1F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0x1F,
  0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x3F, 0xF8, 0xFF, 0x3F, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xDF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0xFF, 0x80, 0x7F,
  0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xF3, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F,
  0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xFF,
  0x3F, 0xFE, 0x07, 0xF7, 0xE7, 0xFF, 0xC0, 0xFE, 0xFD, 0xFB, 0xF8, 0x1F,
  0xDF, 0xBF, 0xFF, 0x03, 0xFB, 0xFF, 0xDF, 0xC0, 0x7F, 0x7F, 0xFB, 0xF8,
  0x1F, 0xEF, 0xFF, 0x7F, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F, 0xFB,
  0xFC, 0x0F, 0xE7, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0xCF, 0xE0, 0x7F, 0x1F,
  0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x8F, 0xF0, 0x3F,
  0x8F, 0xF1, 0xFC, 0x07, 0xF1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x87, 0xF0,
  0x3F, 0x87, 0xF1, 0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0x80, 0x03, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x3F, 0xF0, 0x7F, 0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0xFF,
  0xE1, 0xFC, 0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xE3,
  0xF8, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF9, 0xFC, 0x07, 0xEF, 0xCF, 0xE0,
  0x7F, 0x7F, 0x7F, 0x03, 0xFB, 0xFB, 0xF8, 0x1F, 0xDF, 0xDF, 0xC0, 0xFE,
  0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x03, 0xF8, 0xFF,
  0xF8, 0x1F, 0xC7, 0xFF, 0xC0, 0xFE, 0x3F, 0xFC, 0x07, 0xF1, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0x03, 0xF8, 0x3F, 0xF8, 0x1F, 0xC1, 0xFF, 0x80, 0xFE,
  0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x9F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F,
  0x87, 0xF9, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFE, 0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0xE1, 0xFC, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F,
  0x83, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFE, 0x7C, 0x07, 0xF8, 0x30, 0x0F, 0xF0, 0x20, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x20, 0x1F, 0xE0, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0x7F,
  0x00, 0x7E, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x01,
  0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x07, 0xF9, 0xFC, 0x0F, 0xE0, 0xFF, 0x3F,
  0x83, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF,
  0x1F, 0xC3, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x1F, 0xF8,
  0xFE, 0x0F, 0xE3, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F,
  0xFC, 0xFE, 0x07, 0xF3, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0xE7, 0xF0, 0x1F,
  0xDF, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xC0, 0x7E, 0xFF, 0xF7, 0xF0,
  0x1F, 0xDF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC3,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0,
  0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0xFE,
  0x07, 0xE3, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x9F,
  0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7C, 0x03, 0xF1, 0xFC, 0x1F, 0xE7,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF,
  0xE0, 0x3F, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0x7F,
  0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7E, 0xFF, 0x83, 0xF9,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFC, 0x30, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0x0F, 0xF0, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F,
  0x8F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0x80, 0x3F, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xDF, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F,
  0x7F, 0x0F, 0xEF, 0xE7, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x0C, 0x7F, 0xCF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x01,
  0xFE, 0x7E, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F,
  0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F,
  0x8F, 0xF0, 0x3F, 0x9F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x80, 0x3F, 0x80, 0xF0,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xEF, 0xC0,
  0x7F, 0x7F, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFE, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x80, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x3F, 0x9F, 0xE0, 0x1F, 0xDF, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9,
  0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xE3,
  0xF0, 0x7E, 0x03, 0xF3, 0xFC, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xEF, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x87,
  0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE3, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF,
  0x0F, 0xE3, 0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC7,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x1F, 0x9F, 0xE0,
  0x7E, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xBF, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xCF, 0xF3, 0xF8, 0xFF, 0x7F,
  0x87, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFC,
  0x0F, 0xF3, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x1F, 0xE7, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC,
  0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE,
  0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE7, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0,
  0x3F, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE3, 0xE0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFC,
  0x30, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x20,
  0x3F, 0x8C, 0x1F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x10, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFD, 0xF8, 0x1F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE1, 0xFE, 0xFE, 0x1F,
  0xCF, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0xFE, 0x3F, 0xE3, 0xF9, 0xFC,
  0x7F, 0xC7, 0xF3, 0xF9, 0xFF, 0x8F, 0xE7, 0xF3, 0xFF, 0x3F, 0x8F, 0xE7,
  0xFE, 0x7F, 0x1F, 0xDF, 0xFD, 0xFC, 0x3F, 0x3F, 0xF3, 0xF8, 0x7E, 0x7F,
  0xE7, 0xF0, 0xFD, 0xFF, 0xDF, 0xC1, 0xFB, 0xEF, 0xBF, 0x83, 0xF7, 0xDF,
  0x7E, 0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF,
  0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 33, 12, 0, -32 },
  { 59, 19, 11, 20, 4, -32 },
  { 86, 25, 32, 24, 0, -32 },
  { 186, 21, 37, 21, 1, -34 },
  { 284, 33, 33, 36, 2, -33 },
  { 421, 27, 33, 27, 0, -33 },
  { 533, 9, 11, 11, 4, -32 },
  { 546, 17, 40, 13, 0, -33 },
  { 631, 16, 40, 13, -4, -33 },
  { 711, 19, 21, 20, 3, -35 },
  { 761, 19, 22, 23, 2, -27 },
  { 814, 12, 13, 12, -3, -7 },
  { 834, 13, 6, 14, 0, -15 },
  { 844, 8, 9, 12, 0, -8 },
  { 853, 25, 33, 18, -3, -33 },
  { 957, 20, 33, 21, 1, -33 },
  { 1040, 17, 32, 21, 4, -32 },
  { 1108, 22, 33, 21, -1, -33 },
  { 1199, 22, 33, 21, 0, -33 },
  { 1290, 22, 32, 21, 0, -32 },
  { 1378, 21, 32, 21, 1, -32 },
  { 1462, 22, 33, 21, 1, -33 },
  { 1553, 23, 32, 21, 1, -32 },
  { 1645, 22, 33, 21, 0, -33 },
  { 1736, 20, 33, 21, 1, -33 },
  { 1819, 12, 26, 12, 0, -25 },
  { 1858, 15, 31, 12, -3, -25 },
  { 1917, 19, 22, 23, 2, -27 },
  { 1970, 19, 16, 23, 2, -24 },
  { 2008, 20, 22, 23, 2, -27 },
  { 2063, 18, 34, 17, 1, -33 },
  { 2140, 31, 36, 32, 1, -33 },
  { 2280, 24, 32, 24, -3, -32 },
  { 2376, 24, 32, 23, 0, -32 },
  { 2472, 22, 33, 21, 2, -33 },
  { 2563, 24, 32, 24, 0, -32 },
  { 2659, 21, 32, 19, 0, -32 },
  { 2743, 21, 32, 18, 0, -32 },
  { 2827, 24, 33, 25, 2, -33 },
  { 2926, 27, 32, 25, 0, -32 },
  { 3034, 22, 32, 17, -2, -32 },
  { 3122, 21, 42, 12, -7, -32 },
  { 3233, 28, 32, 23, 0, -32 },
  { 3345, 16, 32, 18, 0, -32 },
  { 3409, 35, 32, 33, 0, -32 },
  { 3549, 29, 32, 27, 0, -32 },
  { 3665, 24, 33, 26, 2, -33 },
  { 3764, 23, 32, 22, 0, -32 },
  { 3856, 24, 41, 26, 2, -33 },
  { 3979, 23, 32, 23, 0, -32 },
  { 4071, 23, 33, 20, -1, -33 },
  { 4166, 20, 32, 19, 3, -32 },
  { 4246, 24, 32, 24, 2, -32 },
  { 4342, 24, 32, 23, 4, -32 },
  { 4438, 35, 32, 33, 3, -32 },
  { 4578, 29, 32, 23, -3, -32 },
  { 4694, 22, 32, 22, 4, -32 },
  { 4782, 25, 32, 20, -2, -32 },
  { 4882, 19, 41, 13, -2, -33 },
  { 4980, 11, 33, 18, 4, -33 },
  { 5026, 19, 41, 13, -4, -33 },
  { 5124, 22, 21, 21, -1, -32 },
  { 5182, 18, 5, 17, -4, 3 },
  { 5194, 10, 7, 15, 6, -34 },
  { 5203, 22, 25, 22, 1, -25 },
  { 5272, 22, 34, 22, -1, -34 },
  { 5366, 18, 25, 18, 1, -25 },
  { 5423, 24, 34, 22, 1, -34 },
  { 5525, 19, 25, 21, 1, -25 },
  { 5585, 24, 45, 14, -5, -34 },
  { 5720, 24, 36, 22, -1, -25 },
  { 5828, 22, 34, 22, -1, -34 },
  { 5922, 15, 35, 11, -1, -35 },
  { 5988, 20, 46, 11, -6, -35 },
  { 6103, 25, 34, 22, -1, -34 },
  { 6210, 15, 34, 11, -1, -34 },
  { 6274, 33, 25, 33, -1, -25 },
  { 6378, 22, 25, 22, -1, -25 },
  { 6447, 20, 25, 22, 1, -25 },
  { 6510, 24, 36, 22, -3, -25 },
  { 6618, 22, 36, 22, 1, -25 },
  { 6717, 19, 25, 16, -1, -25 },
  { 6777, 18, 25, 17, 0, -25 },
  { 6834, 15, 30, 15, 2, -30 },
  { 6891, 22, 25, 22, 1, -25 },
  { 6960, 20, 25, 21, 3, -25 },
  { 7023, 31, 25, 31, 2, -25 },
  { 7120, 25, 25, 21, -2, -25 },
  { 7199, 26, 36, 21, -3, -25 },
  { 7316, 21, 25, 18, -2, -25 },
  { 7382, 19, 39, 16, 0, -32 },
  { 7475, 6, 45, 18, 6, -35 },
  { 7509, 18, 39, 16, -3, -32 },
  { 7597, 20, 8, 23, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC45PT7B_H_
