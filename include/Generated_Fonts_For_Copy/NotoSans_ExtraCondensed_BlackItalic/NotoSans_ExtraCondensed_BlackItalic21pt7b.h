#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE0, 0x03, 0x0F,
  0x1E, 0x38, 0x00, 0x77, 0xFB, 0xBD, 0xDC, 0xEE, 0xE0, 0x07, 0x60, 0x6E,
  0x0E, 0xE0, 0xEC, 0x3F, 0xF3, 0xFE, 0x5D, 0x81, 0x98, 0x3B, 0x8F, 0xFC,
  0xFF, 0xC3, 0x70, 0x76, 0x06, 0x60, 0xEE, 0x00, 0x01, 0x00, 0xC0, 0xFC,
  0x7F, 0x3B, 0x8F, 0x83, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xB9, 0x2E, 0x7F,
  0x3F, 0xC7, 0xE0, 0x40, 0x10, 0x00, 0x3C, 0x38, 0xFC, 0x61, 0xF9, 0xC3,
  0x73, 0x0E, 0xEE, 0x1D, 0xB8, 0x3B, 0x77, 0x7F, 0xDF, 0x7B, 0x76, 0x0E,
  0xCC, 0x19, 0x98, 0x73, 0x70, 0xCE, 0xC3, 0x8F, 0x8E, 0x1E, 0x00, 0x07,
  0x80, 0x7E, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0F, 0xC0, 0x7C, 0x27, 0xEE,
  0x7F, 0xF3, 0xBF, 0x3D, 0xF9, 0xE7, 0x8F, 0xFC, 0x7F, 0xF1, 0xF7, 0x80,
  0x7F, 0xFE, 0xE0, 0x0F, 0x0E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0xF0, 0x0E, 0x27, 0x1B, 0x2F, 0xFF, 0xF8, 0xE1, 0xF8, 0xEE,
  0x36, 0x02, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x3B, 0xDC, 0xEE, 0x70, 0x7F, 0xFF, 0xC0, 0x6F,
  0xFE, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x1F,
  0xCF, 0xEF, 0x77, 0x3B, 0x9F, 0xDF, 0xCF, 0xE7, 0x73, 0xBB, 0xDD, 0xCF,
  0xE7, 0xE1, 0xE0, 0x0F, 0x1F, 0x3E, 0x7E, 0xFE, 0xFE, 0x5E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x07, 0xC1, 0xFC, 0x7F, 0x84, 0xF0,
  0x9E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF8,
  0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0xF1, 0xFC, 0x4F, 0x03, 0xC0, 0xE1, 0xF0,
  0x7C, 0x3F, 0x81, 0xE0, 0x7A, 0x1E, 0xFF, 0x3F, 0x8F, 0xC0, 0x01, 0xC0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x86, 0xE3, 0xF8, 0xDE, 0x77, 0x3F, 0xFF, 0xFB,
  0xFE, 0x0F, 0x03, 0x80, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C, 0x0F,
  0xC3, 0xF8, 0xFE, 0x27, 0x81, 0xE0, 0x7A, 0x1E, 0xFF, 0x3F, 0xCF, 0xC0,
  0x07, 0xC7, 0xE3, 0xF8, 0xE0, 0x78, 0x1D, 0xCF, 0xF3, 0xFC, 0xF7, 0x39,
  0xCE, 0x73, 0xBC, 0xFE, 0x3F, 0x87, 0xC0, 0x3F, 0xDF, 0xF7, 0xF8, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xE7, 0x39, 0xCF, 0xE1, 0xF0, 0x7C,
  0x3F, 0x9D, 0xEF, 0x3B, 0xCE, 0xFF, 0x1F, 0xC7, 0xE0, 0x0F, 0x87, 0xE3,
  0xFC, 0xE7, 0x39, 0xDE, 0xF7, 0xBD, 0xFF, 0x3F, 0x8E, 0xE0, 0x78, 0x3C,
  0xFE, 0x3F, 0x8F, 0x80, 0x18, 0xF3, 0x8E, 0x00, 0x00, 0x00, 0x63, 0xCF,
  0x38, 0x0C, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87,
  0x1C, 0x38, 0x00, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0xC7, 0x83, 0xF0, 0x7F,
  0x0F, 0x80, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x80, 0x70, 0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x7F, 0xFC, 0xF0, 0x60, 0x20,
  0x00, 0x3E, 0x7F, 0x7F, 0x47, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x00,
  0x60, 0xF0, 0xE0, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xE0, 0x73,
  0xBF, 0x66, 0xFC, 0xDD, 0x99, 0xB7, 0x37, 0x6E, 0xEC, 0xD9, 0x9B, 0xBF,
  0x67, 0x7B, 0xC6, 0x22, 0x0E, 0x00, 0x1E, 0x78, 0x1F, 0xF0, 0x06, 0x00,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0xEE, 0x1D, 0xC7, 0xB8, 0xE7, 0x1C,
  0xE7, 0xFC, 0xFF, 0xBF, 0xF7, 0x9F, 0xE3, 0xFC, 0x78, 0x1F, 0xC3, 0xFC,
  0x7F, 0x9E, 0xF3, 0xDE, 0x73, 0xCF, 0xF3, 0xFC, 0x7F, 0xCF, 0x79, 0xCF,
  0x39, 0xEF, 0xF9, 0xFF, 0x3F, 0x80, 0x0F, 0xC7, 0xF3, 0xF9, 0xE2, 0x78,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0xC4, 0xFE, 0x3F, 0x87,
  0xE0, 0x1F, 0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0xCE, 0x71, 0xCE, 0x3B, 0xCF,
  0x79, 0xEF, 0x3D, 0xCF, 0x3B, 0xEF, 0xF9, 0xFE, 0x3F, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0xF0, 0x3C, 0x0E, 0x03, 0xF1, 0xFC, 0x7F, 0x1E, 0x07, 0x01,
  0xC0, 0xFE, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF1, 0xF8, 0xF0, 0x3C, 0x0E,
  0x03, 0xF1, 0xFC, 0x7F, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x07, 0xE3, 0xFC, 0xFF, 0x3E, 0x27, 0x80, 0xE0, 0x3D, 0xF7, 0xBE, 0xF7,
  0xDC, 0x7B, 0x8E, 0x79, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x1E, 0x78, 0xE3,
  0x87, 0x1C, 0x79, 0xE3, 0xCF, 0x1C, 0x78, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xCF, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x79, 0xE3, 0xCF, 0x00, 0x1F, 0xC7,
  0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x1F, 0xCF, 0xE0, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0xBC, 0x3E, 0x0F, 0x83, 0x80, 0x1E, 0x78, 0xE7, 0x87, 0x78, 0x7B,
  0xC3, 0xFC, 0x1D, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1D, 0xE0,
  0xEF, 0x0F, 0x78, 0x79, 0xC3, 0xCF, 0x00, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xFF, 0xFE, 0xFE, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFE, 0x77, 0xDC, 0x77, 0xDC, 0x77, 0x9C, 0xF7, 0xBC,
  0xF7, 0xBC, 0xE7, 0x38, 0x1E, 0x3C, 0x78, 0xE1, 0xE3, 0x8F, 0xCE, 0x3F,
  0x78, 0xFD, 0xC3, 0xF7, 0x1F, 0xDC, 0x7F, 0x71, 0xCF, 0xC7, 0x3E, 0x1C,
  0xF8, 0xF3, 0xE3, 0x8F, 0x8E, 0x3C, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3B, 0x8F, 0x7B, 0xCF,
  0xF9, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0xDE, 0x73,
  0xCE, 0xF3, 0xFE, 0x7F, 0x8F, 0xE1, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3B, 0x8F, 0x7B, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0xDE, 0x73,
  0xCE, 0xF3, 0xFE, 0x7F, 0x0F, 0xE1, 0xDE, 0x3B, 0xCF, 0x79, 0xE7, 0x3C,
  0xF0, 0x0F, 0xC7, 0xF3, 0xFC, 0xF2, 0x38, 0x0F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xC0, 0x73, 0x3C, 0xFF, 0x3F, 0x8F, 0xC0, 0xFF, 0xFF, 0xBF, 0xC7,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x80, 0x3C, 0xE7, 0x1D, 0xE7, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0xF7, 0x9E,
  0xF3, 0xDE, 0x73, 0x8E, 0x73, 0xCF, 0xF1, 0xFE, 0x1F, 0x80, 0xF1, 0xFE,
  0x7B, 0xCF, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0xC7, 0x78, 0xEE, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x71, 0xC7, 0xB8, 0xE7, 0x9C,
  0xF3, 0xCE, 0x79, 0xC7, 0x7D, 0xE3, 0xBE, 0xE1, 0xDF, 0x70, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF,
  0x03, 0xE7, 0x80, 0x1E, 0x78, 0xF7, 0x83, 0xBC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x87, 0xBC,
  0x39, 0xE3, 0xCF, 0x00, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0x7F, 0x1F, 0x87,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x00, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x80, 0x0F, 0x87,
  0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF8, 0x7C, 0x3E, 0x00, 0xE7, 0x38, 0xC7, 0x39,
  0xCE, 0x73, 0x9C, 0x73, 0x9C, 0xE0, 0x0F, 0x87, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x7C, 0x3C, 0x3E, 0x00, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x8F, 0xE3,
  0xB9, 0xCE, 0xF1, 0xF8, 0x70, 0xFF, 0xFF, 0xBF, 0xC0, 0xF3, 0x9E, 0x0C,
  0xE7, 0xF8, 0xFF, 0x3D, 0xE7, 0x3C, 0xE7, 0x3C, 0xE7, 0x9C, 0xF7, 0x9F,
  0xF1, 0xFC, 0x3B, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3F, 0x8F, 0xF3,
  0xFC, 0xEF, 0x7B, 0xDC, 0xF7, 0x3D, 0xCE, 0xF7, 0xBF, 0xEF, 0xF3, 0xB8,
  0x0F, 0x0F, 0xCF, 0xCF, 0x27, 0x83, 0x81, 0xC1, 0xE0, 0xF2, 0x7F, 0x1F,
  0x87, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF1, 0xDC, 0x7F, 0x8F, 0xF3,
  0xDE, 0x73, 0xCE, 0x73, 0xCE, 0x79, 0xCF, 0x79, 0xFF, 0x1F, 0xC3, 0xB8,
  0x0F, 0x07, 0xE3, 0xF9, 0xEF, 0x73, 0x9F, 0xEF, 0xF3, 0xC0, 0xF0, 0x3F,
  0xC7, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0x80, 0xFC, 0x3F, 0x07,
  0xE0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0x06, 0x70, 0xFE, 0x1F,
  0xE3, 0xDE, 0x39, 0xE3, 0x9C, 0x39, 0xC7, 0x9C, 0x7B, 0xC7, 0xFC, 0x7F,
  0x83, 0xB8, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xF0, 0x7C, 0x00, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3B, 0x8F, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0xF7, 0x39,
  0xCE, 0xF3, 0xBD, 0xEE, 0x73, 0x9C, 0x1C, 0x71, 0xC0, 0x3C, 0xE3, 0x8E,
  0x79, 0xC7, 0x1C, 0xF3, 0xCE, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x78,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x1E, 0x3E, 0x1F, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xCE, 0x73, 0x8E, 0xF1, 0xFC, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x8F, 0x71,
  0xEE, 0x39, 0xE7, 0x3C, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x79, 0xC7,
  0x1C, 0xF3, 0xCE, 0x38, 0x3B, 0x9C, 0x7F, 0xFC, 0xFF, 0xF9, 0xDE, 0xF7,
  0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C,
  0xE7, 0x39, 0xC0, 0x3B, 0x8F, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0xF7, 0x39,
  0xCE, 0xF3, 0xBD, 0xEE, 0x73, 0x9C, 0x0F, 0x07, 0xE3, 0xF9, 0xEF, 0x73,
  0xDC, 0xF7, 0x3B, 0xCE, 0xF7, 0x9F, 0xC7, 0xF0, 0xF8, 0x1D, 0xC3, 0xFC,
  0x7F, 0x8E, 0xF3, 0xDE, 0x73, 0xCE, 0x79, 0xCE, 0x79, 0xCF, 0xF9, 0xFE,
  0x3B, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0xE3, 0xF8,
  0xFF, 0x3D, 0xE7, 0x3C, 0xE7, 0x1C, 0xE7, 0x9C, 0xF7, 0x9F, 0xF3, 0xFC,
  0x3B, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x3B, 0x3F, 0x3F,
  0x3F, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x1E, 0x3F, 0x7F,
  0x79, 0x78, 0x7C, 0x3E, 0x1E, 0x8E, 0xFE, 0xFE, 0xFC, 0x18, 0x70, 0xFF,
  0xFF, 0xCE, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0xCF, 0x9F, 0x00, 0x3D, 0xE7,
  0x38, 0xE7, 0x3C, 0xE7, 0xBC, 0xE7, 0x9C, 0xE3, 0x9C, 0xF7, 0x9F, 0xF1,
  0xFC, 0x3F, 0x80, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0xF7, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF7, 0x9F, 0xDE, 0x7F, 0x7B, 0xFB,
  0xEE, 0xEF, 0xBB, 0xBF, 0xCF, 0xFF, 0x3E, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F,
  0x3C, 0x3C, 0xF0, 0x3C, 0xF1, 0xDE, 0x1D, 0xC1, 0xFC, 0x1F, 0x80, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x77, 0x8F, 0x38, 0x3C, 0xF3, 0xCE,
  0x3D, 0xE3, 0xDC, 0x1D, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x00, 0x1F,
  0xC7, 0xF3, 0xF8, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1F, 0xCF,
  0xF3, 0xFC, 0x07, 0x87, 0xC3, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0x78,
  0x78, 0x3E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0x78, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x78, 0xF8, 0xF0,
  0xF0, 0xF8, 0xFF, 0xE7, 0xF0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 15, 5, 0, -15 },
  { 15, 9, 5, 9, 2, -15 },
  { 21, 12, 15, 11, 0, -15 },
  { 44, 10, 17, 10, 0, -16 },
  { 66, 15, 15, 17, 1, -15 },
  { 95, 13, 15, 13, 0, -15 },
  { 120, 4, 5, 5, 2, -15 },
  { 123, 8, 18, 6, 0, -15 },
  { 141, 8, 18, 6, -2, -15 },
  { 159, 9, 10, 9, 1, -16 },
  { 171, 9, 11, 11, 1, -13 },
  { 184, 5, 6, 5, -1, -3 },
  { 188, 6, 3, 6, 0, -7 },
  { 191, 4, 4, 5, 0, -4 },
  { 193, 11, 15, 8, -1, -15 },
  { 214, 9, 15, 10, 1, -15 },
  { 231, 8, 15, 10, 2, -15 },
  { 246, 11, 15, 10, -1, -15 },
  { 267, 10, 15, 10, 0, -15 },
  { 286, 10, 15, 10, 0, -15 },
  { 305, 10, 15, 10, 0, -15 },
  { 324, 10, 15, 10, 1, -15 },
  { 343, 10, 15, 10, 1, -15 },
  { 362, 10, 15, 10, 0, -15 },
  { 381, 10, 15, 10, 0, -15 },
  { 400, 6, 12, 6, 0, -12 },
  { 409, 7, 15, 6, -1, -12 },
  { 423, 9, 11, 11, 1, -13 },
  { 436, 9, 7, 11, 1, -11 },
  { 444, 9, 11, 11, 1, -13 },
  { 457, 8, 15, 8, 1, -15 },
  { 472, 15, 17, 15, 0, -15 },
  { 504, 11, 15, 11, -1, -15 },
  { 525, 11, 15, 11, 0, -15 },
  { 546, 10, 15, 10, 1, -15 },
  { 565, 11, 15, 11, 0, -15 },
  { 586, 10, 15, 9, 0, -15 },
  { 605, 10, 15, 9, 0, -15 },
  { 624, 11, 15, 12, 1, -15 },
  { 645, 13, 15, 12, 0, -15 },
  { 670, 10, 15, 8, -1, -15 },
  { 689, 10, 20, 6, -3, -15 },
  { 714, 13, 15, 11, 0, -15 },
  { 739, 8, 15, 8, 0, -15 },
  { 754, 16, 15, 16, 0, -15 },
  { 784, 14, 15, 13, 0, -15 },
  { 811, 11, 15, 12, 1, -15 },
  { 832, 11, 15, 10, 0, -15 },
  { 853, 11, 19, 12, 1, -15 },
  { 880, 11, 15, 11, 0, -15 },
  { 901, 10, 15, 9, 0, -15 },
  { 920, 9, 15, 9, 2, -15 },
  { 937, 11, 15, 11, 1, -15 },
  { 958, 11, 15, 11, 2, -15 },
  { 979, 17, 15, 16, 1, -15 },
  { 1011, 13, 15, 11, -1, -15 },
  { 1036, 10, 15, 10, 2, -15 },
  { 1055, 12, 15, 9, -1, -15 },
  { 1078, 9, 19, 6, -1, -15 },
  { 1100, 5, 15, 8, 2, -15 },
  { 1110, 9, 19, 6, -2, -15 },
  { 1132, 10, 10, 10, 0, -15 },
  { 1145, 9, 3, 8, -2, 1 },
  { 1149, 5, 3, 7, 3, -16 },
  { 1151, 11, 12, 10, 0, -12 },
  { 1168, 10, 16, 10, 0, -16 },
  { 1188, 9, 12, 8, 0, -12 },
  { 1202, 11, 16, 10, 0, -16 },
  { 1224, 10, 12, 10, 0, -12 },
  { 1239, 11, 21, 6, -2, -16 },
  { 1268, 12, 17, 10, -1, -12 },
  { 1294, 10, 16, 10, 0, -16 },
  { 1314, 6, 16, 5, 0, -16 },
  { 1326, 9, 21, 5, -3, -16 },
  { 1350, 11, 16, 10, 0, -16 },
  { 1372, 6, 16, 5, 0, -16 },
  { 1384, 15, 12, 15, 0, -12 },
  { 1407, 10, 12, 10, 0, -12 },
  { 1422, 10, 12, 10, 0, -12 },
  { 1437, 11, 17, 10, -1, -12 },
  { 1461, 11, 17, 10, 0, -12 },
  { 1485, 8, 12, 7, 0, -12 },
  { 1497, 8, 12, 8, 0, -12 },
  { 1509, 7, 14, 7, 1, -14 },
  { 1522, 11, 12, 10, 0, -12 },
  { 1539, 10, 12, 10, 1, -12 },
  { 1554, 14, 12, 14, 1, -12 },
  { 1575, 12, 12, 10, -1, -12 },
  { 1593, 12, 17, 10, -1, -12 },
  { 1619, 10, 12, 8, -1, -12 },
  { 1634, 9, 18, 7, 0, -15 },
  { 1655, 3, 21, 8, 3, -16 },
  { 1663, 8, 18, 7, -1, -15 },
  { 1681, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC21PT7B_H_
