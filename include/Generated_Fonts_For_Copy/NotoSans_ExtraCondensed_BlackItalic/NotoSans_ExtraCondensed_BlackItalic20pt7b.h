#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x70, 0x02, 0x3C, 0xF3, 0x80,
  0xF7, 0xE7, 0xEE, 0xEE, 0xEE, 0x06, 0xE1, 0xD8, 0x33, 0x06, 0xE3, 0xFE,
  0xFF, 0xC6, 0xE1, 0xD8, 0xFF, 0xDF, 0xF8, 0xD8, 0x3B, 0x06, 0xE1, 0xDC,
  0x00, 0x02, 0x01, 0xE1, 0xFC, 0xFE, 0x3C, 0x8F, 0x03, 0xC0, 0x7C, 0x0F,
  0x03, 0xC4, 0xB1, 0xBC, 0xFF, 0x3F, 0x81, 0x00, 0x40, 0x3C, 0x39, 0xF1,
  0x86, 0xEE, 0x3B, 0x30, 0xED, 0xC3, 0x36, 0x6F, 0xBB, 0xDE, 0xDB, 0x07,
  0xEC, 0x1B, 0xB0, 0xCC, 0xC7, 0x37, 0x18, 0xF8, 0xE1, 0xC0, 0x0F, 0x81,
  0xFC, 0x1D, 0xC1, 0xDC, 0x1F, 0x81, 0xF0, 0x1E, 0x77, 0xFE, 0x7F, 0xEF,
  0x7C, 0xE7, 0xCF, 0xFC, 0xFF, 0xC7, 0xDE, 0xFE, 0xEE, 0xE0, 0x0E, 0x1C,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0xE0, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xF0, 0x0E, 0x26, 0x1F, 0x5F,
  0xF3, 0xF9, 0xE1, 0xF8, 0x6E, 0x24, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3B, 0x9C, 0xEE, 0x70, 0x7D,
  0xFF, 0x80, 0x2F, 0xFE, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00,
  0x1F, 0x1F, 0x9F, 0xCE, 0xF7, 0x77, 0xBB, 0x9D, 0xCE, 0xE7, 0x77, 0x3B,
  0x9F, 0xCF, 0xC3, 0xC0, 0x0F, 0x1E, 0x3E, 0x7E, 0xFC, 0x5C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x0F, 0xC7, 0xF1, 0xDC, 0x27, 0x01,
  0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x7F, 0xBF, 0xC0,
  0x1F, 0x8F, 0xF1, 0xBC, 0x0E, 0x03, 0x87, 0xC1, 0xC0, 0xFC, 0x07, 0x01,
  0xC8, 0x73, 0xFC, 0xFE, 0x3F, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x1B,
  0x87, 0xC3, 0x71, 0xDC, 0xFF, 0xBF, 0xEF, 0xF8, 0x38, 0x0E, 0x07, 0x80,
  0x1F, 0xC7, 0xE1, 0xF8, 0xE0, 0x38, 0x0F, 0xC3, 0xF0, 0xBE, 0x07, 0x81,
  0xC8, 0x73, 0xFC, 0xFE, 0x3F, 0x00, 0x0F, 0x8F, 0xCF, 0x2F, 0x07, 0x47,
  0xF3, 0xFD, 0xEE, 0xE7, 0x77, 0xBB, 0xDF, 0xCF, 0xE3, 0xC0, 0x7F, 0xDF,
  0xE7, 0xF8, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xEF, 0x3B, 0x8F, 0xC1,
  0xE0, 0xFC, 0x77, 0x3D, 0xEE, 0x73, 0xFC, 0x7E, 0x1F, 0x00, 0x1F, 0x87,
  0xE3, 0xF8, 0xEF, 0x7B, 0xDE, 0xE7, 0xF9, 0xFE, 0x3F, 0x81, 0xC0, 0xF3,
  0xF8, 0xFC, 0x3E, 0x00, 0x39, 0xCE, 0x20, 0x00, 0x04, 0xF7, 0xB8, 0x1C,
  0x71, 0xC2, 0x00, 0x00, 0x00, 0x39, 0xC7, 0x1C, 0xE3, 0x80, 0x01, 0x83,
  0xC7, 0xEF, 0xCF, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0x80, 0x40, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3F, 0x07, 0xE0,
  0xF8, 0xFD, 0xF9, 0xF0, 0xE0, 0x40, 0x00, 0x7E, 0xFD, 0xB8, 0x70, 0xE3,
  0x8E, 0x38, 0x70, 0x01, 0x07, 0x0E, 0x1C, 0x00, 0x07, 0xF0, 0x3C, 0xE1,
  0xC1, 0xCE, 0x7B, 0x37, 0xED, 0xD9, 0xB6, 0xEE, 0xDB, 0x33, 0x6C, 0xDB,
  0xB7, 0x6E, 0xFF, 0x19, 0x98, 0x60, 0x01, 0xE7, 0x03, 0xFC, 0x00, 0x80,
  0x03, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC7, 0xF1, 0xDC, 0x77, 0x3F, 0xCF,
  0xF7, 0xFD, 0xC7, 0xF1, 0xFC, 0x70, 0x1F, 0xC3, 0xF8, 0xFF, 0x9C, 0xF3,
  0x9C, 0x7F, 0x9F, 0xC3, 0xFC, 0x73, 0x8E, 0x71, 0xCE, 0x7F, 0xCF, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xE3, 0xD9, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x23, 0xF8, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0xFF,
  0x9C, 0xF3, 0x9E, 0x73, 0xDE, 0x7B, 0xCE, 0x71, 0xCE, 0x79, 0xDE, 0x7F,
  0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0x03, 0x81, 0xF9, 0xFC,
  0xFE, 0x70, 0x38, 0x1C, 0x1F, 0xCF, 0xE7, 0xE0, 0x1F, 0x8F, 0xCF, 0xE7,
  0x03, 0x81, 0xC1, 0xFC, 0xFC, 0x7E, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x00,
  0x0F, 0xE3, 0xF8, 0xF7, 0x3C, 0x07, 0x01, 0xE0, 0x3D, 0xF7, 0x3C, 0xEB,
  0x9C, 0x73, 0x9E, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x1C, 0x71, 0xCF, 0x3C,
  0xE3, 0x8E, 0x38, 0xE3, 0xFE, 0x7F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C, 0x73,
  0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0x1F, 0xC7, 0xE0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7E, 0x3F, 0x80, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0xF1, 0xDE, 0x3D,
  0xC3, 0xBC, 0x3B, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77,
  0x8F, 0x78, 0xF7, 0x8E, 0x78, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x1E, 0x3C,
  0x70, 0xE1, 0xC7, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0xFC, 0x76, 0xDC, 0x77, 0xDC,
  0x77, 0xFC, 0x77, 0xB8, 0xF7, 0xB8, 0xE7, 0x38, 0xE7, 0x78, 0x1E, 0x38,
  0xF3, 0xCF, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0xB9, 0xFF, 0x8E, 0xFC, 0x77,
  0xE3, 0xBF, 0x1C, 0xF9, 0xE7, 0x8E, 0x3C, 0x71, 0xE0, 0x02, 0x07, 0xE3,
  0xFC, 0xFF, 0x79, 0xDC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x9E,
  0xFF, 0x3F, 0xC7, 0xC0, 0x1F, 0x87, 0xF3, 0xFC, 0xE7, 0x39, 0xCE, 0xF7,
  0xF9, 0xFE, 0x7F, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x02, 0x07,
  0xE3, 0xFC, 0xFF, 0x79, 0xDC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3B,
  0x9E, 0xFF, 0x3F, 0xC7, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x1F, 0x87, 0xF3,
  0xFC, 0xE7, 0x39, 0xCE, 0xF7, 0xF9, 0xFE, 0x7F, 0x1D, 0xC7, 0x73, 0xDE,
  0xF7, 0xB9, 0xE0, 0x1F, 0xCF, 0xE3, 0xF8, 0xE2, 0x38, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x03, 0xC8, 0xF3, 0xFC, 0xFE, 0x3F, 0x00, 0x7F, 0xBF, 0xDF,
  0xE3, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x07,
  0x80, 0x39, 0xEF, 0x39, 0xE7, 0x38, 0xE7, 0x3C, 0xE7, 0xBC, 0xE7, 0x9C,
  0xE3, 0x9C, 0xF3, 0x9C, 0x7F, 0x8F, 0xE0, 0xF8, 0x00, 0xE3, 0xF8, 0xEE,
  0x3B, 0x9E, 0xE7, 0x3B, 0xCE, 0xE3, 0xB8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3C, 0x00, 0x71, 0xCF, 0x73, 0xCE, 0x73, 0xDE, 0x77, 0xDC, 0x77,
  0x9C, 0x77, 0xBC, 0x7F, 0xB8, 0x7F, 0xB8, 0x7D, 0xF0, 0xFD, 0xF0, 0xF9,
  0xF0, 0xF9, 0xE0, 0xF9, 0xE0, 0xF3, 0xC0, 0x1E, 0xF1, 0xEE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x87,
  0xB8, 0x73, 0xCF, 0x3C, 0xE3, 0xF9, 0xEF, 0x73, 0xF8, 0x7E, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x3F, 0xC7, 0xF9, 0xFE, 0x00, 0x0F, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xF8, 0xF8,
  0xE7, 0x39, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0x63, 0x1C, 0x0F, 0x87, 0xC3,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x78, 0x7C, 0x00, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xF1,
  0xDD, 0xCE, 0xE7, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xF7, 0x70, 0x1D, 0xCF,
  0xF7, 0xF9, 0xCE, 0x73, 0x9C, 0xEF, 0x7B, 0xDC, 0xFF, 0x1F, 0xC7, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x3F, 0x8F, 0xE3, 0xF9, 0xEF, 0x73, 0x9C,
  0xE7, 0x3B, 0xDE, 0xFF, 0x3F, 0xCF, 0xE0, 0x1F, 0x9F, 0x8F, 0xCE, 0x07,
  0x03, 0x83, 0xC1, 0xE4, 0xFE, 0x3F, 0x1F, 0x00, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE1, 0xDC, 0x7F, 0x9F, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xDE, 0x7B,
  0x8F, 0xF0, 0xFE, 0x1D, 0xC0, 0x1F, 0x1F, 0xCE, 0xEE, 0x77, 0xFB, 0xFB,
  0xC1, 0xE0, 0xF2, 0x3F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x74, 0x1C, 0x0F,
  0x87, 0xE1, 0xF8, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x3E, 0x0F, 0x03, 0x80, 0x0E, 0xE3, 0xFC, 0x7F, 0x1C,
  0xE3, 0x9C, 0x73, 0x9E, 0xF3, 0xDC, 0x7F, 0x8F, 0xF0, 0xEE, 0x03, 0xC8,
  0x71, 0xFE, 0x3F, 0x83, 0xE0, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0xF9, 0xFC,
  0xFE, 0xF7, 0x73, 0xB9, 0xDC, 0xFE, 0xFE, 0x77, 0x3B, 0x9C, 0x08, 0x71,
  0xC6, 0x00, 0xE3, 0x8E, 0x79, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0x01, 0x01,
  0xC0, 0xE0, 0x60, 0x00, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x3E, 0x1F, 0x0F, 0x00, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x9E, 0x77, 0x8F, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1,
  0xFC, 0x7F, 0x8E, 0x71, 0xCE, 0x39, 0xE0, 0x1C, 0x73, 0xCE, 0x38, 0xE3,
  0x9E, 0x71, 0xC7, 0x3C, 0xE3, 0x8E, 0x00, 0x3F, 0xBC, 0xFF, 0xF3, 0xFF,
  0xDE, 0xE7, 0x73, 0x9D, 0xCE, 0xF7, 0x7B, 0xBD, 0xCE, 0xE7, 0x3B, 0x9C,
  0xEE, 0xF7, 0x80, 0x3F, 0x9F, 0xCF, 0xEF, 0x77, 0x3B, 0x9D, 0xCF, 0xEF,
  0xE7, 0x73, 0xB9, 0xC0, 0x1F, 0x1F, 0xCE, 0xEE, 0x77, 0x3B, 0x9F, 0xCF,
  0xEE, 0xFF, 0x3F, 0x0F, 0x00, 0x1F, 0xC7, 0xF1, 0xDC, 0xF7, 0x39, 0xCE,
  0x73, 0x9D, 0xEF, 0x7F, 0x9F, 0xE7, 0x71, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0x1D, 0xCF, 0xF3, 0xF9, 0xCE, 0x73, 0x9C, 0xEF, 0x7B, 0xDC, 0xFF,
  0x3F, 0xC7, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x3F, 0x3F, 0x3E,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x3F, 0x3F, 0x7A, 0x78,
  0x7C, 0x3C, 0x1E, 0x1E, 0xFE, 0xFC, 0xF8, 0x18, 0x71, 0xFF, 0xEF, 0xCE,
  0x1C, 0x70, 0xE1, 0xC3, 0xE7, 0xCF, 0x80, 0x39, 0xCE, 0x73, 0xBD, 0xEE,
  0x73, 0x9C, 0xE7, 0x7B, 0xDE, 0xFF, 0x3F, 0xC7, 0x70, 0xE3, 0xF3, 0xF9,
  0xDD, 0xEE, 0xE7, 0x71, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xE7, 0xBF,
  0x9E, 0xEE, 0xFB, 0xBB, 0xFC, 0xFF, 0x73, 0xFD, 0x8F, 0xBE, 0x3E, 0xF8,
  0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x00, 0x3D, 0xE3, 0xB8, 0x7F, 0x0F, 0xC1,
  0xF0, 0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0xF3, 0xDE, 0x00, 0x38, 0xE7,
  0x3C, 0xE7, 0x1D, 0xE1, 0xF8, 0x37, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x1F, 0x9F, 0xCF, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x7F, 0x7F, 0xBF, 0x80, 0x07, 0x0F, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0xE0, 0xF0, 0x78, 0x78, 0x70, 0x70, 0x78,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E,
  0x1E, 0x0E, 0x1E, 0x1C, 0x1C, 0x0F, 0x07, 0x1E, 0x3C, 0x38, 0x38, 0x78,
  0xF8, 0xF0, 0xE0, 0xF0, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 11, 14, 11, 0, -14 },
  { 37, 10, 16, 9, 0, -15 },
  { 57, 14, 14, 16, 1, -14 },
  { 82, 12, 14, 12, 0, -14 },
  { 103, 4, 5, 5, 2, -14 },
  { 106, 7, 18, 6, 0, -15 },
  { 122, 8, 18, 6, -2, -15 },
  { 140, 9, 9, 9, 1, -15 },
  { 151, 9, 10, 10, 1, -12 },
  { 163, 5, 6, 5, -1, -3 },
  { 167, 6, 3, 6, 0, -7 },
  { 170, 4, 4, 5, 0, -4 },
  { 172, 11, 14, 8, -1, -14 },
  { 192, 9, 14, 9, 1, -14 },
  { 208, 8, 14, 9, 2, -14 },
  { 222, 10, 14, 9, -1, -14 },
  { 240, 10, 14, 9, 0, -14 },
  { 258, 10, 14, 9, 0, -14 },
  { 276, 10, 14, 9, 0, -14 },
  { 294, 9, 14, 9, 1, -14 },
  { 310, 10, 14, 9, 1, -14 },
  { 328, 10, 14, 9, 0, -14 },
  { 346, 10, 14, 9, 0, -14 },
  { 364, 5, 11, 5, 0, -11 },
  { 371, 6, 14, 5, -1, -11 },
  { 382, 9, 10, 10, 1, -12 },
  { 394, 9, 8, 10, 1, -11 },
  { 403, 9, 10, 10, 1, -12 },
  { 415, 7, 14, 8, 1, -14 },
  { 428, 14, 16, 14, 0, -14 },
  { 456, 10, 14, 11, -1, -14 },
  { 474, 11, 14, 10, 0, -14 },
  { 494, 10, 14, 9, 1, -14 },
  { 512, 11, 14, 11, 0, -14 },
  { 532, 9, 14, 8, 0, -14 },
  { 548, 9, 14, 8, 0, -14 },
  { 564, 11, 14, 11, 1, -14 },
  { 584, 12, 14, 11, 0, -14 },
  { 605, 10, 14, 7, -1, -14 },
  { 623, 9, 18, 6, -3, -14 },
  { 644, 12, 14, 10, 0, -14 },
  { 665, 7, 14, 8, 0, -14 },
  { 678, 16, 14, 15, 0, -14 },
  { 706, 13, 14, 12, 0, -14 },
  { 729, 10, 15, 11, 1, -15 },
  { 748, 10, 14, 10, 0, -14 },
  { 766, 10, 18, 11, 1, -15 },
  { 789, 10, 14, 10, 0, -14 },
  { 807, 10, 14, 9, 0, -14 },
  { 825, 9, 14, 9, 1, -14 },
  { 841, 11, 14, 11, 1, -14 },
  { 861, 10, 14, 10, 2, -14 },
  { 879, 16, 14, 15, 1, -14 },
  { 907, 12, 14, 10, -1, -14 },
  { 928, 10, 14, 10, 2, -14 },
  { 946, 11, 14, 9, -1, -14 },
  { 966, 8, 18, 6, -1, -15 },
  { 984, 5, 14, 8, 2, -14 },
  { 993, 9, 18, 6, -2, -15 },
  { 1014, 9, 9, 9, 0, -14 },
  { 1025, 8, 3, 8, -2, 1 },
  { 1028, 4, 3, 7, 3, -15 },
  { 1030, 10, 11, 10, 0, -11 },
  { 1044, 10, 15, 10, 0, -15 },
  { 1063, 9, 11, 8, 0, -11 },
  { 1076, 11, 15, 10, 0, -15 },
  { 1097, 9, 11, 9, 0, -11 },
  { 1110, 10, 20, 6, -2, -15 },
  { 1135, 11, 16, 10, -1, -11 },
  { 1157, 9, 15, 10, 0, -15 },
  { 1174, 6, 16, 5, 0, -16 },
  { 1186, 9, 21, 5, -3, -16 },
  { 1210, 11, 15, 10, 0, -15 },
  { 1231, 6, 15, 5, 0, -15 },
  { 1243, 14, 11, 15, 0, -11 },
  { 1263, 9, 11, 10, 0, -11 },
  { 1276, 9, 11, 10, 0, -11 },
  { 1289, 10, 16, 10, -1, -11 },
  { 1309, 10, 16, 10, 0, -11 },
  { 1329, 8, 11, 7, 0, -11 },
  { 1340, 8, 11, 8, 0, -11 },
  { 1351, 7, 13, 7, 1, -13 },
  { 1363, 10, 11, 10, 0, -11 },
  { 1377, 9, 11, 9, 1, -11 },
  { 1390, 14, 11, 14, 1, -11 },
  { 1410, 11, 11, 9, -1, -11 },
  { 1426, 11, 16, 9, -1, -11 },
  { 1448, 9, 11, 8, -1, -11 },
  { 1461, 8, 17, 7, 0, -14 },
  { 1478, 3, 20, 8, 2, -15 },
  { 1486, 8, 17, 7, -1, -14 },
  { 1503, 9, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC20PT7B_H_
