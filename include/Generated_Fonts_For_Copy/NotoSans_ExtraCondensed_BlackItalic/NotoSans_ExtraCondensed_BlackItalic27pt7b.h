#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x40, 0x00, 0x30, 0xF8, 0xF8, 0xF8, 0xF0, 0x7D, 0xF7, 0xDE, 0x79,
  0xE7, 0x9E, 0x7B, 0xC7, 0x3C, 0xF3, 0xC0, 0x03, 0xDE, 0x07, 0x38, 0x0E,
  0x70, 0x3D, 0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70,
  0x1D, 0xE0, 0x73, 0x83, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C,
  0xE0, 0x7B, 0x80, 0xE7, 0x01, 0xDE, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7E, 0xC3, 0xA0, 0x1F, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF1, 0x0B, 0x8C, 0xFC, 0x7F, 0xE3, 0xFE,
  0x3F, 0xE0, 0x7E, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xF0, 0x78, 0x3F, 0x87, 0x03, 0xF8, 0xF0, 0x7B, 0x8E, 0x07, 0x39, 0xE0,
  0x73, 0x9C, 0x07, 0x7B, 0x80, 0xF7, 0x79, 0xC7, 0xF7, 0x3E, 0x7E, 0xF7,
  0xF7, 0xCE, 0xF7, 0x11, 0xEE, 0x70, 0x1D, 0xEF, 0x03, 0x9E, 0xF0, 0x39,
  0xCE, 0x07, 0x1C, 0xE0, 0xF1, 0xFC, 0x0E, 0x0F, 0xC1, 0xE0, 0xF8, 0x00,
  0x40, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xCF, 0x1F, 0xDF, 0x3F, 0xDE, 0x7F,
  0xFE, 0xFB, 0xFC, 0xF9, 0xFC, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0x7E, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x00, 0x03, 0xC1, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x01, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x0E, 0x01, 0xE1, 0x3C, 0x37, 0x1F,
  0xFF, 0xFF, 0xDF, 0xF8, 0xF8, 0x3F, 0x1F, 0xF1, 0xCF, 0x19, 0xC0, 0x20,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x7C, 0xF1, 0xE3,
  0xCF, 0x1E, 0x78, 0x7F, 0x7F, 0x7E, 0xFE, 0x37, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x01, 0x00, 0x7E, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xCF, 0x7C, 0xF7,
  0x8F, 0x79, 0xFF, 0x9F, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF,
  0x7C, 0xFF, 0x8F, 0xF8, 0x7F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x3F, 0x0F,
  0xE3, 0xFD, 0xFF, 0x9F, 0xE1, 0xBC, 0x2F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x40,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0x7C, 0x11, 0xF0, 0x47, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x01, 0x80, 0x7F,
  0x87, 0xFE, 0x3F, 0xF0, 0xCF, 0x84, 0x7C, 0x03, 0xC0, 0x3E, 0x0F, 0xE0,
  0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x90, 0x7C, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x1D, 0xE1, 0xCF, 0x1E, 0xF8,
  0xE7, 0xCF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x3C, 0x03, 0xC0, 0x3F, 0x03,
  0xFC, 0x7F, 0xC7, 0xFC, 0x27, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x87, 0xCF,
  0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x60, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE1, 0xF1, 0x1F, 0x00, 0xF0, 0x0F, 0xB8, 0x7F, 0xC3, 0xFF, 0x3F, 0xF9,
  0xF3, 0xCF, 0x9E, 0x79, 0xF3, 0xCF, 0x9E, 0x78, 0xFF, 0xC7, 0xFC, 0x1F,
  0xE0, 0x7C, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xC0,
  0x3F, 0x83, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xE3, 0xDE, 0x1F,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0xC7, 0xDE, 0x3C, 0xF3, 0xE7, 0xDF, 0x3C,
  0xFB, 0xE7, 0xFE, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x80, 0x3F, 0x03, 0xFC,
  0x3F, 0xE1, 0xEF, 0x9F, 0x7C, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9, 0xEF, 0xCF,
  0xFC, 0x7F, 0xE3, 0xFF, 0x04, 0xF0, 0x0F, 0x80, 0x78, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC1, 0xFC, 0x00, 0x1E, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC3, 0xCF, 0x9F, 0x3C, 0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0x8F,
  0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xF0, 0x07, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x03,
  0xF0, 0xFF, 0x3F, 0xCF, 0xF0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x02, 0x07,
  0xE7, 0xFD, 0xFF, 0x37, 0xD0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x38, 0x10, 0x00, 0x00, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x00,
  0x10, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3E, 0x1E, 0x1E, 0x03, 0xCF, 0x1C,
  0x73, 0x9F, 0xDD, 0xCF, 0xF7, 0x77, 0xBD, 0xF9, 0xCE, 0x7E, 0x73, 0x9F,
  0xB8, 0xE6, 0xEE, 0x7B, 0xBB, 0x9C, 0xEC, 0xFF, 0xF3, 0x9F, 0xF8, 0xE7,
  0x9C, 0x38, 0x00, 0x0F, 0x00, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xFF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E, 0xF8, 0x7F, 0xF1,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0x1F, 0x7C, 0x3E, 0xF8, 0x7F, 0xF0,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x79, 0xF3,
  0xE7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0x9F, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x00,
  0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xF7, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x08, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3C, 0x78, 0x78, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1E, 0x7C,
  0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x40,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFB, 0x87, 0xC1, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF3, 0xF3, 0xE7, 0xE7, 0xCF, 0xCF, 0xBF, 0x9F, 0x1E,
  0x3E, 0x3C, 0x7C, 0x78, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0x1F, 0x87, 0x9F, 0x07, 0xCF, 0x83, 0xEF, 0x81, 0xE7,
  0x80, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0xC0, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x0F, 0x03, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xFF, 0xFF, 0xBF, 0xEF, 0xF8, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0xFF,
  0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xEF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xBC, 0x3D, 0xFD, 0xE1, 0xEF, 0xCF, 0x0F, 0x7E,
  0xF8, 0xFB, 0xE7, 0xC7, 0x9F, 0x3C, 0x3C, 0x71, 0xE0, 0x0F, 0x87, 0x87,
  0xC3, 0xC7, 0xE1, 0xE3, 0xF9, 0xF1, 0xFC, 0xF0, 0xFE, 0x78, 0xFF, 0x3C,
  0x7F, 0x9E, 0x3F, 0xFF, 0x1E, 0xFF, 0x0F, 0x7F, 0x8F, 0xBF, 0xC7, 0x9F,
  0xE3, 0xCF, 0xF1, 0xE3, 0xF0, 0xF1, 0xF8, 0xF8, 0xFC, 0x78, 0x7E, 0x3C,
  0x3E, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xC7,
  0xC7, 0x9F, 0x0F, 0xBE, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E,
  0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x7F, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xC7,
  0xC7, 0x9F, 0x0F, 0xBE, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E, 0x7C, 0x79, 0xF3,
  0xE7, 0xCF, 0xBE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0x9E, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x00, 0x00,
  0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0x08, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF2, 0x0F, 0x98,
  0x7C, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x9F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F,
  0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0xF0, 0xFF, 0xC3, 0xEF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE3, 0xCF, 0x8F,
  0x3E, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0xF0, 0xFF, 0xC7, 0x8F, 0xBE, 0x3C, 0x7D, 0xF3, 0xE3, 0xCF, 0x9F, 0x3E,
  0x7D, 0xF9, 0xE3, 0xCF, 0xCF, 0x1E, 0x7E, 0xF8, 0xF7, 0xF7, 0x87, 0xBF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E,
  0x00, 0x07, 0xCF, 0xC1, 0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x79,
  0xE0, 0x3E, 0x78, 0x1F, 0x1F, 0x0F, 0xC7, 0xC0, 0xF1, 0xFF, 0x8F, 0xBC,
  0xF9, 0xF7, 0xCF, 0xFC, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x00, 0xE3, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xE7, 0x9E, 0x79,
  0xE7, 0x8E, 0x3C, 0xF3, 0xCF, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDE, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0xBE,
  0x0F, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0xFB, 0xE7, 0x8F, 0x3C, 0x0F, 0x3C,
  0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0xF8, 0x7F, 0xE1, 0xF7, 0x83, 0x9C,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x7B,
  0xC3, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0xBE, 0x79, 0xF7, 0xCF, 0xBC, 0x79,
  0xE3, 0xCF, 0x3E, 0x79, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x8E, 0x78, 0x00,
  0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x83, 0xDE,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F,
  0x1E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xF7, 0xC1, 0xFF, 0x83, 0xFF,
  0x03, 0xDC, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF3, 0xEF, 0x3C, 0xF7, 0xDF,
  0x7F, 0xE7, 0xFC, 0x7F, 0x0F, 0x80, 0xF8, 0x07, 0xCC, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0x00, 0x38, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x2F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0x9E, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xE7, 0xC7,
  0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF,
  0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE1, 0x87, 0xC3,
  0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xC3, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x3E,
  0x79, 0xF7, 0xCF, 0x3E, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE7, 0xCF, 0x3E,
  0x79, 0xE7, 0xCF, 0x3E, 0x00, 0x07, 0x0F, 0x1F, 0x1F, 0x0C, 0x00, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x18, 0x00, 0x00, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x85, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3C, 0x3E, 0xF8, 0x7B, 0xE0, 0xF7,
  0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xE1,
  0xF7, 0xC3, 0xCF, 0x87, 0x8F, 0x0F, 0x1F, 0x00, 0x0F, 0x0F, 0x0F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x1C, 0xF3, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xEF, 0x9E, 0x79, 0xE7, 0xDF, 0x3C, 0xFB, 0xE7, 0x9E,
  0x79, 0xF3, 0xCF, 0x3E, 0x79, 0xE7, 0x9F, 0x7C, 0xF3, 0xEF, 0x9E, 0x79,
  0xE7, 0xCF, 0x3C, 0xFB, 0xE0, 0x1C, 0xF0, 0xEF, 0x8F, 0xFE, 0x7F, 0xF3,
  0xEF, 0x9E, 0x7D, 0xF3, 0xCF, 0x9E, 0x78, 0xF3, 0xCF, 0x9E, 0x79, 0xF3,
  0xCF, 0x9E, 0x79, 0xF3, 0xCF, 0x80, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF,
  0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x9F, 0xF9, 0xE7, 0xFE,
  0x7F, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x3C, 0x0E, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF8,
  0x79, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0x78, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x3C, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79,
  0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0xE3,
  0xB8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x1E,
  0x67, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF2, 0x1E, 0x7F, 0xCF,
  0xF9, 0xFE, 0x3F, 0x80, 0x0E, 0x07, 0x07, 0x87, 0xF7, 0xFF, 0xFF, 0xFC,
  0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xF9, 0xFC, 0xFE, 0x3F,
  0x00, 0x3C, 0xFB, 0xE7, 0x9F, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xFB, 0xE7,
  0x9F, 0x3C, 0xF3, 0xE7, 0x9F, 0x3C, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xEF, 0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xEF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x00, 0x79, 0xF3, 0xEF, 0x3E, 0x79, 0xEF, 0xCF, 0x3D, 0xFB, 0xC7, 0xBF,
  0x78, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xBF, 0xF8, 0x7E, 0xFE, 0x1F, 0xDF,
  0xC3, 0xFB, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3E, 0x3E,
  0x00, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xEF, 0x07,
  0xDE, 0x0F, 0x3C, 0x3E, 0x7C, 0x00, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x5F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x01,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x0F,
  0xC1, 0xF0, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 12, 7, 12, 2, -19 },
  { 31, 15, 19, 14, 0, -19 },
  { 67, 13, 23, 13, 0, -21 },
  { 105, 20, 20, 21, 1, -20 },
  { 155, 16, 20, 16, 0, -20 },
  { 195, 6, 7, 7, 2, -19 },
  { 201, 10, 24, 8, 0, -20 },
  { 231, 9, 24, 8, -2, -20 },
  { 258, 11, 13, 12, 2, -21 },
  { 276, 12, 13, 14, 1, -16 },
  { 296, 7, 8, 7, -2, -4 },
  { 303, 8, 4, 8, 0, -9 },
  { 307, 5, 5, 7, 0, -5 },
  { 311, 15, 20, 11, -2, -20 },
  { 349, 12, 20, 13, 1, -20 },
  { 379, 11, 19, 13, 2, -19 },
  { 406, 14, 20, 13, -1, -20 },
  { 441, 13, 20, 13, 0, -20 },
  { 474, 13, 19, 13, 0, -19 },
  { 505, 12, 19, 13, 1, -19 },
  { 534, 13, 20, 13, 1, -20 },
  { 567, 13, 19, 13, 1, -19 },
  { 598, 13, 20, 13, 0, -20 },
  { 631, 13, 20, 13, 0, -20 },
  { 664, 7, 15, 7, 0, -15 },
  { 678, 9, 19, 7, -2, -15 },
  { 700, 12, 13, 14, 1, -16 },
  { 720, 12, 9, 14, 1, -14 },
  { 734, 12, 13, 14, 1, -16 },
  { 754, 10, 20, 10, 1, -20 },
  { 779, 18, 22, 19, 1, -20 },
  { 829, 15, 19, 14, -2, -19 },
  { 865, 14, 19, 14, 0, -19 },
  { 899, 13, 20, 13, 1, -20 },
  { 932, 15, 19, 15, 0, -19 },
  { 968, 13, 19, 11, 0, -19 },
  { 999, 13, 19, 11, 0, -19 },
  { 1030, 15, 20, 15, 1, -20 },
  { 1068, 16, 19, 15, 0, -19 },
  { 1106, 13, 19, 10, -1, -19 },
  { 1137, 13, 25, 7, -4, -19 },
  { 1178, 17, 19, 14, 0, -19 },
  { 1219, 10, 19, 11, 0, -19 },
  { 1243, 21, 19, 20, 0, -19 },
  { 1293, 17, 19, 16, 0, -19 },
  { 1334, 15, 20, 16, 1, -20 },
  { 1372, 14, 19, 13, 0, -19 },
  { 1406, 15, 25, 16, 1, -20 },
  { 1453, 14, 19, 14, 0, -19 },
  { 1487, 13, 20, 12, 0, -20 },
  { 1520, 12, 19, 12, 2, -19 },
  { 1549, 15, 19, 15, 1, -19 },
  { 1585, 14, 19, 14, 3, -19 },
  { 1619, 21, 19, 20, 2, -19 },
  { 1669, 18, 19, 14, -2, -19 },
  { 1712, 13, 19, 13, 3, -19 },
  { 1743, 15, 19, 12, -1, -19 },
  { 1779, 11, 25, 8, -1, -20 },
  { 1814, 6, 20, 11, 3, -20 },
  { 1829, 11, 25, 8, -2, -20 },
  { 1864, 14, 12, 13, -1, -19 },
  { 1885, 12, 3, 10, -3, 2 },
  { 1890, 6, 5, 9, 4, -21 },
  { 1894, 14, 15, 13, 0, -15 },
  { 1921, 13, 21, 13, 0, -21 },
  { 1956, 12, 15, 11, 0, -15 },
  { 1979, 15, 21, 13, 0, -21 },
  { 2019, 12, 15, 12, 0, -15 },
  { 2042, 14, 27, 8, -3, -21 },
  { 2090, 15, 21, 13, -1, -15 },
  { 2130, 13, 21, 13, 0, -21 },
  { 2165, 8, 21, 7, 0, -21 },
  { 2186, 11, 27, 7, -3, -21 },
  { 2224, 15, 21, 13, 0, -21 },
  { 2264, 8, 21, 7, 0, -21 },
  { 2285, 19, 15, 20, 0, -15 },
  { 2321, 13, 15, 13, 0, -15 },
  { 2346, 12, 15, 13, 0, -15 },
  { 2369, 15, 21, 13, -2, -15 },
  { 2409, 14, 21, 13, 0, -15 },
  { 2446, 11, 15, 10, 0, -15 },
  { 2467, 11, 15, 10, 0, -15 },
  { 2488, 9, 18, 9, 1, -18 },
  { 2509, 13, 15, 13, 1, -15 },
  { 2534, 12, 15, 12, 2, -15 },
  { 2557, 19, 15, 18, 1, -15 },
  { 2593, 15, 15, 12, -1, -15 },
  { 2622, 16, 21, 12, -2, -15 },
  { 2664, 12, 15, 11, -1, -15 },
  { 2687, 11, 23, 9, 0, -19 },
  { 2719, 4, 27, 11, 3, -21 },
  { 2733, 11, 23, 9, -2, -19 },
  { 2765, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC27PT7B_H_
