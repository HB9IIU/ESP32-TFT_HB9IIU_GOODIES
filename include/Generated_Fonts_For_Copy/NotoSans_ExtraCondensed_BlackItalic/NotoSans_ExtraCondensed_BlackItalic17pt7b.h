#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x67, 0x39, 0xCC, 0x03, 0x39, 0xC0, 0xEF, 0xDB, 0x76,
  0xE0, 0x0D, 0x83, 0x61, 0xB1, 0xFF, 0x7F, 0x8D, 0x83, 0x63, 0xFC, 0xFF,
  0x1B, 0x06, 0xC3, 0xF0, 0x04, 0x0E, 0x3F, 0x3F, 0x38, 0x38, 0x3C, 0x1E,
  0x0E, 0x56, 0xFE, 0xFC, 0x10, 0x20, 0x78, 0xC7, 0x9C, 0xD9, 0x8D, 0xB0,
  0xDB, 0x0F, 0xEF, 0xF7, 0xF0, 0xDB, 0x1D, 0xB1, 0x9B, 0x31, 0xE3, 0x1C,
  0x0F, 0x07, 0xC3, 0xB0, 0xFC, 0x3E, 0x0F, 0x77, 0xFD, 0xBE, 0xEF, 0xBB,
  0xCF, 0xF1, 0xEE, 0xFF, 0x60, 0x1C, 0x63, 0x8C, 0x71, 0x86, 0x18, 0xE3,
  0x8E, 0x38, 0xE3, 0x86, 0x00, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE3, 0x1C, 0x63, 0x8C, 0x00, 0x18, 0xB1, 0xFF, 0xF3, 0x9F, 0x9B, 0x14,
  0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x77, 0x6E, 0x7F, 0xFE, 0x7F,
  0x80, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38,
  0x18, 0x1C, 0x00, 0x3C, 0xFD, 0xFF, 0x7E, 0xFD, 0xF3, 0xE6, 0xDD, 0xBB,
  0xE7, 0x80, 0x0E, 0x3C, 0xFF, 0xE7, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1,
  0xC0, 0x1E, 0x3F, 0x37, 0x27, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE2, 0xFC,
  0xFC, 0x3F, 0x3F, 0x27, 0x07, 0x0E, 0x3C, 0x3E, 0x0E, 0x0E, 0x9E, 0xFC,
  0xF8, 0x07, 0x0F, 0x0F, 0x1E, 0x36, 0x3E, 0x6E, 0xFF, 0xFF, 0xFE, 0x1C,
  0x1C, 0x1F, 0x3F, 0x38, 0x30, 0x3C, 0x7E, 0x2E, 0x0E, 0x0E, 0x9E, 0xFC,
  0xF8, 0x1F, 0x3E, 0x70, 0x60, 0xFC, 0xFC, 0xEE, 0xCE, 0xCC, 0xDC, 0xFC,
  0x78, 0x3F, 0x9F, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x1E, 0x00, 0x1F, 0x3F, 0x33, 0x37, 0x3E, 0x1C, 0x3E, 0x7E, 0xE6,
  0xEE, 0xFE, 0x7C, 0x1E, 0x3F, 0x37, 0x77, 0x77, 0x77, 0x7F, 0x36, 0x0E,
  0x1C, 0xFC, 0xF0, 0x11, 0xDC, 0x40, 0x00, 0x0C, 0xE7, 0x00, 0x08, 0x73,
  0x84, 0x00, 0x00, 0x00, 0x71, 0xC6, 0x38, 0x06, 0x3D, 0xF7, 0x8F, 0x07,
  0xC3, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE1, 0xF0, 0xF3,
  0xFF, 0x38, 0x40, 0x7F, 0xF5, 0xC7, 0x39, 0xC6, 0x18, 0x03, 0x0E, 0x30,
  0x07, 0xC1, 0xC6, 0x38, 0x33, 0x7F, 0x6D, 0xB6, 0xDB, 0x59, 0xBD, 0x92,
  0xDF, 0xEC, 0xDC, 0x60, 0x07, 0x18, 0x3F, 0x00, 0x07, 0x83, 0xC3, 0xE1,
  0xF1, 0xF8, 0xFC, 0xEE, 0x7F, 0x3F, 0xBF, 0xDC, 0xFC, 0x70, 0x3F, 0x1F,
  0xCE, 0xE7, 0x73, 0x73, 0xF1, 0xFC, 0xEE, 0x67, 0x77, 0xBF, 0x9F, 0x80,
  0x1F, 0x3F, 0x72, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C,
  0x3F, 0x1F, 0xCE, 0xE7, 0x73, 0x3B, 0x9D, 0xCE, 0xE7, 0x67, 0x7F, 0xBF,
  0x9F, 0x00, 0x3F, 0x3F, 0x38, 0x38, 0x3E, 0x7E, 0x7C, 0x70, 0x60, 0xE0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x38, 0x38, 0x30, 0x7E, 0x7C, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0x1F, 0x9F, 0x9E, 0x4E, 0x0E, 0x07, 0x7B, 0xBD, 0xCE, 0xE6,
  0x77, 0x3F, 0x8F, 0x80, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x3F, 0x9F, 0xE7,
  0xF9, 0xCE, 0x63, 0x39, 0xCE, 0x73, 0x9C, 0x1F, 0x8F, 0x83, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1F, 0x1F, 0x80, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x78, 0x78,
  0xE0, 0x39, 0xCE, 0xE3, 0xB8, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E,
  0x3B, 0x8E, 0x73, 0x9C, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x8F,
  0xFF, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xF3, 0xDF, 0x3E, 0xF9, 0xF7,
  0xCF, 0xEE, 0x6F, 0x67, 0x7F, 0x3B, 0xB9, 0xDD, 0xC0, 0x3C, 0xE7, 0x9C,
  0xF3, 0x1E, 0x63, 0xDC, 0xFF, 0x9F, 0xF3, 0xFC, 0x67, 0x9C, 0xF3, 0x9E,
  0x73, 0xC0, 0x1F, 0x1F, 0x9C, 0xEE, 0x7E, 0x3F, 0x1F, 0x9D, 0xCE, 0xE7,
  0x77, 0x3F, 0x8F, 0x00, 0x3F, 0x1F, 0x8E, 0xE7, 0x73, 0x33, 0xF9, 0xF8,
  0xF8, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0x1F, 0x9C, 0xEE, 0x7E, 0x3F,
  0x1F, 0x9D, 0xCE, 0xE7, 0x77, 0x3F, 0x8F, 0x01, 0xC0, 0xE0, 0x78, 0x3F,
  0x1F, 0xCE, 0xE7, 0x73, 0x7B, 0xF9, 0xF8, 0xFC, 0x6E, 0x77, 0x3B, 0x9C,
  0xE0, 0x1F, 0x3F, 0x7A, 0x70, 0x78, 0x3C, 0x3E, 0x0E, 0x8E, 0xFE, 0xFC,
  0xF8, 0x7F, 0xFE, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60,
  0xE0, 0x73, 0xB9, 0xDC, 0xCE, 0xEE, 0x77, 0x3B, 0x9D, 0xCC, 0xCE, 0x77,
  0x3F, 0x0F, 0x00, 0xE7, 0xC7, 0xCE, 0xCE, 0xDC, 0xDC, 0xD8, 0xF8, 0xF8,
  0xF0, 0xF0, 0xE0, 0x67, 0x3B, 0x39, 0xF9, 0xDD, 0xDE, 0xEE, 0xF6, 0x7F,
  0xF3, 0xEF, 0x9F, 0xF8, 0xFF, 0xC7, 0xBE, 0x3D, 0xE1, 0xCF, 0x00, 0x1D,
  0xE3, 0xB8, 0x7E, 0x0F, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3F, 0x07,
  0xE1, 0xDC, 0x73, 0xC0, 0xE7, 0xEE, 0xFC, 0xFC, 0xF8, 0xF8, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0xC7, 0xE2, 0x38, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x1C, 0x47, 0xE3, 0xF8, 0x1E, 0x3C, 0x60, 0xC3, 0x87,
  0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1E, 0x3C, 0x00, 0xCC, 0xCE, 0xEE,
  0x66, 0x66, 0x67, 0x1E, 0x78, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70,
  0xC1, 0x83, 0x1E, 0x3C, 0x00, 0x0C, 0x0E, 0x1E, 0x3E, 0x36, 0x76, 0x67,
  0xC7, 0x7F, 0xFC, 0xF7, 0x30, 0x10, 0x9F, 0x9F, 0xCE, 0xE6, 0x77, 0x33,
  0xB9, 0xDC, 0xFE, 0x3F, 0x00, 0x38, 0x38, 0x38, 0x3A, 0x3F, 0x7F, 0x77,
  0x77, 0x67, 0x67, 0xEE, 0xFE, 0xDC, 0x0C, 0x7D, 0xFB, 0x86, 0x1C, 0x38,
  0x72, 0x7C, 0xF0, 0x03, 0x81, 0xC0, 0xE2, 0x73, 0xF3, 0xF9, 0xDC, 0xCE,
  0xE6, 0x73, 0x3B, 0x9F, 0xC7, 0xE0, 0x0C, 0x3E, 0x7F, 0x77, 0x7E, 0xFC,
  0xE0, 0xE2, 0x7C, 0x7C, 0x03, 0x83, 0xC3, 0xA1, 0xC1, 0xF0, 0xF8, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC1, 0xE0, 0xE0, 0x00,
  0x18, 0x9F, 0x9F, 0xCE, 0xE6, 0x77, 0x33, 0xB9, 0xDC, 0xFE, 0x3F, 0x03,
  0x13, 0x8F, 0xC7, 0xC0, 0x38, 0x38, 0x38, 0x36, 0x3F, 0x7F, 0x77, 0x77,
  0x67, 0x66, 0xEE, 0xEE, 0xEE, 0x19, 0xC4, 0x13, 0x39, 0xCE, 0x63, 0x39,
  0xCE, 0x00, 0x06, 0x1C, 0x10, 0x10, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x86, 0x1C, 0x78, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x3B, 0xB9,
  0xF8, 0xF8, 0x7C, 0x3E, 0x3B, 0x9D, 0xCE, 0xE0, 0x39, 0xCE, 0x73, 0x39,
  0xCE, 0x63, 0x39, 0xCE, 0x00, 0x02, 0x23, 0xFF, 0x7F, 0xF7, 0x77, 0x77,
  0x76, 0x67, 0x66, 0x6E, 0xEE, 0xEE, 0xEE, 0xEE, 0x06, 0x3F, 0x7F, 0x77,
  0x77, 0x67, 0x66, 0xEE, 0xEE, 0xEE, 0x0C, 0x3E, 0x7F, 0x77, 0x67, 0xE7,
  0xE6, 0xEE, 0x7C, 0x78, 0x01, 0x0F, 0xCF, 0xE7, 0x73, 0xB9, 0x9C, 0xCE,
  0xEE, 0x7F, 0x3F, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x18, 0x9F, 0x9F, 0xCE,
  0xE6, 0x77, 0x33, 0x99, 0xDC, 0xFE, 0x3F, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x06, 0x7D, 0xF3, 0xE7, 0x0C, 0x18, 0x70, 0xE1, 0xC0, 0x18, 0x7D, 0xF3,
  0x87, 0x87, 0x87, 0x4E, 0xF9, 0xF0, 0x33, 0xBF, 0xFE, 0x73, 0x9C, 0xC7,
  0xBC, 0x33, 0xBB, 0x9D, 0xCE, 0xE6, 0x77, 0x33, 0xB9, 0xFC, 0x7E, 0x00,
  0xEF, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xEE, 0xFF, 0xDF,
  0xFB, 0x6F, 0xEF, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x00, 0x3B, 0xC6,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE1, 0xD8, 0xE7, 0x00, 0x3B, 0xCE,
  0xE3, 0xB0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0x70, 0x1C, 0x0E, 0x0B, 0x83,
  0xC0, 0xE0, 0x00, 0x3F, 0x3F, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x7E, 0xFC,
  0x0E, 0x3C, 0x70, 0xC3, 0x87, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x78, 0x70,
  0xE1, 0xC3, 0x87, 0x8E, 0x3C, 0x70, 0xC3, 0x8F, 0x1E, 0x30, 0x00, 0x43,
  0xFF, 0xFC, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 7, 4, 8, 2, -12 },
  { 13, 10, 12, 9, 0, -12 },
  { 28, 8, 14, 8, 0, -13 },
  { 42, 12, 12, 13, 1, -12 },
  { 60, 10, 12, 10, 0, -12 },
  { 75, 3, 4, 4, 2, -12 },
  { 77, 6, 15, 5, 0, -12 },
  { 89, 6, 15, 5, -1, -12 },
  { 101, 7, 8, 8, 1, -13 },
  { 108, 7, 8, 9, 1, -10 },
  { 115, 4, 4, 4, -1, -2 },
  { 117, 5, 3, 5, 0, -6 },
  { 119, 3, 3, 4, 0, -3 },
  { 121, 9, 12, 7, -1, -12 },
  { 135, 7, 12, 8, 1, -12 },
  { 146, 7, 12, 8, 1, -12 },
  { 157, 8, 12, 8, 0, -12 },
  { 169, 8, 12, 8, 0, -12 },
  { 181, 8, 12, 8, 0, -12 },
  { 193, 8, 12, 8, 0, -12 },
  { 205, 8, 12, 8, 1, -12 },
  { 217, 9, 12, 8, 0, -12 },
  { 231, 8, 12, 8, 0, -12 },
  { 243, 8, 12, 8, 0, -12 },
  { 255, 5, 10, 5, 0, -10 },
  { 262, 6, 12, 5, -1, -10 },
  { 271, 7, 8, 9, 1, -10 },
  { 278, 7, 6, 9, 1, -9 },
  { 284, 7, 8, 9, 1, -10 },
  { 291, 6, 12, 6, 1, -12 },
  { 300, 12, 13, 12, 0, -12 },
  { 320, 9, 12, 9, -1, -12 },
  { 334, 9, 12, 9, 0, -12 },
  { 348, 8, 12, 8, 1, -12 },
  { 360, 9, 12, 9, 0, -12 },
  { 374, 8, 12, 7, 0, -12 },
  { 386, 8, 12, 7, 0, -12 },
  { 398, 9, 12, 9, 1, -12 },
  { 412, 10, 12, 10, 0, -12 },
  { 427, 9, 12, 6, -1, -12 },
  { 441, 8, 16, 5, -3, -12 },
  { 457, 10, 12, 9, 0, -12 },
  { 472, 6, 12, 7, 0, -12 },
  { 481, 13, 12, 13, 0, -12 },
  { 501, 11, 12, 10, 0, -12 },
  { 518, 9, 12, 10, 1, -12 },
  { 532, 9, 12, 8, 0, -12 },
  { 546, 9, 15, 10, 1, -12 },
  { 563, 9, 12, 9, 0, -12 },
  { 577, 8, 12, 7, 0, -12 },
  { 589, 8, 12, 7, 1, -12 },
  { 601, 9, 12, 9, 1, -12 },
  { 615, 8, 12, 9, 2, -12 },
  { 627, 13, 12, 13, 1, -12 },
  { 647, 11, 12, 9, -1, -12 },
  { 664, 8, 12, 8, 2, -12 },
  { 676, 10, 12, 7, -1, -12 },
  { 691, 7, 15, 5, -1, -12 },
  { 705, 4, 12, 7, 2, -12 },
  { 711, 7, 15, 5, -1, -12 },
  { 725, 8, 8, 8, 0, -12 },
  { 733, 7, 2, 7, -2, 1 },
  { 735, 4, 3, 6, 2, -13 },
  { 737, 9, 10, 8, 0, -10 },
  { 749, 8, 13, 8, 0, -13 },
  { 762, 7, 10, 7, 0, -10 },
  { 771, 9, 13, 8, 0, -13 },
  { 786, 8, 10, 8, 0, -10 },
  { 796, 9, 17, 5, -2, -13 },
  { 816, 9, 14, 8, 0, -10 },
  { 832, 8, 13, 8, 0, -13 },
  { 845, 5, 13, 4, 0, -13 },
  { 854, 7, 17, 4, -2, -13 },
  { 869, 9, 13, 8, 0, -13 },
  { 884, 5, 13, 4, 0, -13 },
  { 893, 12, 10, 12, 0, -10 },
  { 908, 8, 10, 8, 0, -10 },
  { 918, 8, 10, 8, 0, -10 },
  { 928, 9, 14, 8, -1, -10 },
  { 944, 9, 14, 8, 0, -10 },
  { 960, 7, 10, 6, 0, -10 },
  { 969, 7, 10, 7, 0, -10 },
  { 978, 5, 11, 6, 1, -11 },
  { 985, 9, 9, 8, 0, -9 },
  { 996, 8, 9, 8, 1, -9 },
  { 1005, 11, 9, 12, 1, -9 },
  { 1018, 10, 9, 8, -1, -9 },
  { 1030, 10, 13, 8, -1, -9 },
  { 1047, 8, 9, 7, -1, -9 },
  { 1056, 7, 15, 6, 0, -12 },
  { 1070, 3, 17, 7, 2, -13 },
  { 1077, 7, 15, 6, -1, -12 },
  { 1091, 7, 4, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC17PT7B_H_
