#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x61, 0x00, 0xBC, 0x33, 0x76, 0xFA, 0x27, 0x42, 0xAC, 0x69,
  0xAB, 0x57, 0x2D, 0x30, 0x32, 0x99, 0xFB, 0x78, 0xC0, 0x29, 0x49, 0x20,
  0x24, 0x92, 0xB0, 0xDF, 0xA0, 0x22, 0xF2, 0xE0, 0xC0, 0x80, 0x12, 0x64,
  0xC8, 0x25, 0x5F, 0xAE, 0x7F, 0x25, 0x80, 0x67, 0x36, 0xCE, 0x67, 0x26,
  0x2E, 0x33, 0x6A, 0xF6, 0x74, 0x6A, 0x2E, 0x36, 0x6F, 0xEE, 0x71, 0x22,
  0x4C, 0x35, 0x66, 0xAE, 0x27, 0xF7, 0x2C, 0x42, 0x46, 0x80, 0x16, 0xE1,
  0xF0, 0xF0, 0x86, 0x7C, 0x6C, 0xA1, 0x80, 0x39, 0x17, 0x6D, 0xBA, 0x46,
  0x00, 0x37, 0x57, 0xFB, 0x75, 0x7F, 0xFE, 0x37, 0x4C, 0xC6, 0x75, 0x5D,
  0xFE, 0x74, 0x6E, 0xCE, 0x74, 0x4E, 0xC8, 0x3B, 0x91, 0xED, 0x38, 0x7A,
  0xDD, 0xED, 0x58, 0x76, 0x44, 0x4E, 0x32, 0x22, 0x64, 0x48, 0x7A, 0x99,
  0xCE, 0x58, 0x69, 0x6D, 0xC0, 0x6D, 0xB7, 0xFF, 0xFA, 0xA0, 0x6B, 0x5F,
  0xEF, 0x58, 0x33, 0xD7, 0xAD, 0x30, 0x75, 0x5E, 0xC8, 0x33, 0xD7, 0xAD,
  0x30, 0xC0, 0x75, 0x5E, 0xEB, 0x75, 0x46, 0xAE, 0xEB, 0x49, 0x00, 0x5A,
  0x95, 0xAF, 0x70, 0xBA, 0xAC, 0xCC, 0xAE, 0xAE, 0xBC, 0xF2, 0xC0, 0x5A,
  0x98, 0xCE, 0x58, 0xBA, 0xCC, 0x88, 0x73, 0x24, 0xCE, 0x69, 0x69, 0x30,
  0xAA, 0xB0, 0x32, 0x22, 0x26, 0xC0, 0x26, 0x69, 0xF0, 0xC0, 0x47, 0xFA,
  0xE0, 0x46, 0x7F, 0xFE, 0x2F, 0x4E, 0x15, 0x7F, 0xAE, 0x27, 0xE8, 0xE0,
  0x32, 0x72, 0x64, 0x4C, 0x47, 0xFA, 0xE2, 0xC0, 0x46, 0x7F, 0xAA, 0x47,
  0xE0, 0x20, 0xB6, 0x96, 0x44, 0x7E, 0xEA, 0x57, 0xE0, 0x29, 0xFF, 0xFA,
  0xA8, 0x27, 0xFA, 0xA0, 0x27, 0xFA, 0xE0, 0x11, 0xDE, 0xF7, 0x23, 0x00,
  0x47, 0xFA, 0xE2, 0x60, 0x2F, 0x48, 0x5D, 0x3C, 0x5D, 0x6C, 0x5F, 0xEE,
  0xF6, 0x64, 0xFF, 0xED, 0xB4, 0x76, 0x6A, 0xF6, 0x64, 0xC8, 0xEB, 0x70,
  0x2D, 0x65, 0xB0, 0xFF, 0x49, 0x3D, 0xA0, 0x5F,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 4, 6, 4, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 6, 6, 6, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 2, 0, -6 },
  { 24, 3, 7, 2, -1, -6 },
  { 27, 3, 4, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 2, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 3, 6, 4, 1, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 4, 3, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 3, 6, 3, 0, -6 },
  { 79, 6, 7, 6, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 4, 6, 3, 0, -6 },
  { 100, 4, 6, 3, 0, -6 },
  { 103, 5, 6, 4, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 4, 6, 3, 0, -6 },
  { 114, 4, 8, 2, -1, -6 },
  { 118, 5, 6, 4, 0, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 6, 6, 6, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 5, 7, 5, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 3, 0, -6 },
  { 152, 3, 6, 3, 1, -6 },
  { 155, 5, 6, 4, 0, -6 },
  { 159, 4, 6, 4, 1, -6 },
  { 162, 6, 6, 6, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 3, 7, 2, 0, -6 },
  { 180, 2, 6, 3, 1, -6 },
  { 182, 4, 7, 2, -1, -6 },
  { 186, 4, 4, 4, 0, -6 },
  { 188, 4, 1, 3, -1, 0 },
  { 189, 2, 1, 3, 1, -6 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 4, 6, 4, 0, -6 },
  { 196, 3, 5, 3, 0, -5 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 4, 5, 4, 0, -5 },
  { 204, 4, 8, 2, -1, -6 },
  { 208, 4, 7, 4, 0, -5 },
  { 212, 4, 6, 4, 0, -6 },
  { 215, 2, 6, 2, 0, -6 },
  { 217, 3, 8, 2, -1, -6 },
  { 220, 4, 6, 4, 0, -6 },
  { 223, 2, 6, 2, 0, -6 },
  { 225, 6, 5, 6, 0, -5 },
  { 229, 4, 5, 4, 0, -5 },
  { 232, 4, 5, 4, 0, -5 },
  { 235, 5, 7, 4, -1, -5 },
  { 240, 4, 7, 4, 0, -5 },
  { 244, 3, 5, 3, 0, -5 },
  { 246, 3, 5, 3, 0, -5 },
  { 248, 3, 5, 3, 0, -5 },
  { 250, 4, 4, 4, 0, -4 },
  { 252, 4, 4, 4, 0, -4 },
  { 254, 6, 4, 5, 0, -4 },
  { 257, 4, 4, 4, 0, -4 },
  { 259, 4, 6, 4, 0, -4 },
  { 262, 3, 4, 3, 0, -4 },
  { 264, 3, 7, 3, 0, -6 },
  { 267, 1, 8, 3, 1, -6 },
  { 268, 3, 7, 3, 0, -6 },
  { 271, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC8PT7B_H_
