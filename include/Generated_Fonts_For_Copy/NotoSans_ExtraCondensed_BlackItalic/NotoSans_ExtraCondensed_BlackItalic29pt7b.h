#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0xBE, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF,
  0x3C, 0x01, 0xEF, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0xDE, 0x03, 0x9C, 0x07,
  0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x3C, 0xE0, 0x39, 0xE0, 0x39,
  0xC0, 0x79, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x00, 0x60, 0x01, 0x00, 0x3F,
  0x81, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xE9, 0x87, 0xA0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x10, 0xBC, 0x72,
  0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x1E, 0x03, 0xC3, 0xF0, 0x78, 0x7F, 0x87, 0x07, 0xF8, 0xF0, 0xF7,
  0x8E, 0x0F, 0x79, 0xE0, 0xE7, 0xBC, 0x0E, 0x73, 0xC0, 0xE7, 0x79, 0xCE,
  0xF7, 0x3F, 0xFE, 0xF7, 0xFF, 0xCE, 0xFF, 0x79, 0xEE, 0x70, 0x1C, 0xE7,
  0x03, 0xDE, 0x70, 0x79, 0xE7, 0x07, 0x1E, 0xF0, 0xF1, 0xEE, 0x0E, 0x1F,
  0xE1, 0xE0, 0xFC, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF3, 0xC7, 0xFB, 0xE7, 0xFD, 0xF7, 0xFF, 0xF3, 0xEF, 0xFB,
  0xE7, 0xF9, 0xF3, 0xF8, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xF3, 0xF0, 0x7D, 0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0x03, 0xE0, 0xF8,
  0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x47, 0x07, 0x73,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF1, 0xF0, 0x3F, 0x8F, 0xFC, 0x7B, 0xE3, 0x3C,
  0x11, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0x9F,
  0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x3F, 0xF3, 0xEF, 0x9F, 0x7C, 0xF3, 0xEF,
  0x9F, 0x7C, 0xFB, 0xC7, 0xFE, 0x3D, 0xF3, 0xEF, 0x9F, 0x7C, 0xFB, 0xC7,
  0x9E, 0x7C, 0xF3, 0xC7, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xFC, 0xFF, 0xBF, 0xE7, 0xBC, 0x6F, 0x89,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0,
  0xF7, 0xE0, 0xC7, 0xC1, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x0C, 0x7C, 0x21, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x17, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x83, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x0E,
  0xF0, 0x7F, 0xC3, 0xDF, 0x0E, 0x7C, 0x79, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0x00, 0xF8, 0x07, 0xB0, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x87, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x70, 0x7F,
  0xE1, 0xFF, 0xCF, 0xFF, 0x3F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x78, 0xFB, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0x7C, 0x79, 0xF1, 0xE7, 0xC7,
  0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xF1, 0xF3, 0xC7,
  0x8F, 0x3E, 0x3C, 0xF9, 0xF3, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7B,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFE,
  0x00, 0x1E, 0x1F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x07, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFF, 0x9F, 0xF3, 0xFC, 0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x07, 0xF8, 0xFF, 0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00,
  0x00, 0x0F, 0x87, 0xFD, 0xFF, 0x9F, 0xF3, 0x3E, 0x43, 0xC0, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x1E, 0x1E, 0x00, 0xE1, 0xC7, 0xCE, 0x38, 0xFE, 0xE7,
  0x9F, 0xEF, 0x73, 0xDE, 0xE7, 0x39, 0xCE, 0xF7, 0x9C, 0xEE, 0x71, 0xCE,
  0xE7, 0x3C, 0xEE, 0x73, 0x9C, 0xE7, 0x79, 0xCE, 0x7F, 0xF8, 0xE7, 0xDF,
  0x0E, 0x10, 0x60, 0xF0, 0x00, 0x0F, 0x00, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xDF, 0x07, 0xDF,
  0x07, 0xDF, 0x0F, 0x9F, 0x0F, 0x9F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0x0F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xCF, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x7E, 0x7C, 0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x98, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x43, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7D,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x8C, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x02, 0x7C, 0xFC, 0xFD, 0xFC, 0xF9, 0xFC, 0xF9,
  0xFC, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0xF8, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFC,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x0C, 0x00, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0,
  0xF9, 0xF0, 0x3C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xEF, 0xF8,
  0x7F, 0xDF, 0xF0, 0xFF, 0xBF, 0xE1, 0xEF, 0xF7, 0x83, 0xDF, 0xFF, 0x0F,
  0xBF, 0xBE, 0x1F, 0x7F, 0x7C, 0x3E, 0xFC, 0xF0, 0x79, 0xF9, 0xE0, 0xF3,
  0xF7, 0xC3, 0xE7, 0xCF, 0x87, 0xCF, 0x9F, 0x0F, 0x9E, 0x3C, 0x00, 0x0F,
  0xC3, 0xE1, 0xF8, 0x78, 0x3F, 0x0F, 0x07, 0xE3, 0xE1, 0xFC, 0x7C, 0x3F,
  0xCF, 0x87, 0xF9, 0xE0, 0xFF, 0x3C, 0x3F, 0xEF, 0x87, 0xFD, 0xF0, 0xFF,
  0xBE, 0x1E, 0xFF, 0x83, 0xDF, 0xF0, 0xF9, 0xFE, 0x1F, 0x3F, 0xC3, 0xE7,
  0xF8, 0x78, 0xFE, 0x0F, 0x1F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E,
  0x3F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xF7, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x7C,
  0x7C, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x3F, 0x3E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF7,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x7E, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3,
  0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xF1, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x20,
  0xFC, 0x71, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0x80, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF,
  0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xFB, 0xE1, 0xE7, 0xC3, 0xDF,
  0x07, 0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x78, 0x78, 0x7D, 0xE1,
  0xE1, 0xF7, 0x87, 0x87, 0x9E, 0x3E, 0x3E, 0x78, 0xF8, 0xFB, 0xE7, 0xE7,
  0xCF, 0x9F, 0x9F, 0x3E, 0x7E, 0x7C, 0xFB, 0xFB, 0xE3, 0xEF, 0xEF, 0x8F,
  0xFF, 0xBC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFD, 0xFE, 0x0F, 0xF7,
  0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F,
  0x3E, 0x01, 0xE7, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0xF9, 0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7F, 0xE3, 0xEF,
  0x8F, 0xBE, 0x7C, 0xF9, 0xE3, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1,
  0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x3E, 0x78, 0x78,
  0xF1, 0xE1, 0xE7, 0xC3, 0xDF, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0xF9, 0xF3, 0xCF, 0x0F, 0xBE, 0x3F, 0x78, 0x7F, 0xF1, 0xFF, 0xE3, 0xEF,
  0xCF, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xF3, 0xE7, 0xC7,
  0xCF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x1E, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xEF, 0x07, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x7D, 0xF1, 0xF7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xDF, 0x00,
  0x0F, 0xE3, 0xFC, 0xFF, 0xBF, 0xE7, 0xC5, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x4F, 0xF9, 0xFF, 0x3F, 0xE3, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0xBC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x7C, 0x78, 0x7C, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3D, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x7F,
  0xF3, 0xC7, 0xBE, 0x7D, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3, 0xC0, 0x3E, 0x00,
  0xF0, 0x47, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0xDF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x1E, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0xC3, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xEF, 0x87, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x79,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xC7, 0x80, 0x02, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0x20, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x3F, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7B, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF1, 0xF8, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0x80, 0x1E, 0xF9, 0xF0, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xE7, 0xCF, 0x1F, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF8, 0x1E, 0xF8,
  0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3C, 0x78, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7C, 0xFF, 0x8F, 0xF8,
  0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x3E, 0xFF, 0xEF, 0xFC, 0x7F,
  0x83, 0xF0, 0x07, 0xBE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F,
  0x0F, 0x9F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF8, 0x3D, 0xF0, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xBE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF, 0x8F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x1E, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0xF1, 0xFE, 0x3F,
  0xE3, 0xFE, 0x3F, 0xC3, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0xE1, 0xFF, 0x3F,
  0xE3, 0xEC, 0x3C, 0x43, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xC8, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x0F, 0x03, 0xC1, 0xE0,
  0xFF, 0x7F, 0xDF, 0xEF, 0xF8, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x3E, 0x0F, 0x83, 0xF8, 0xFE, 0x3F, 0x87, 0xE0, 0x3E, 0x7C, 0xF1, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xDE, 0x1E, 0x70,
  0xF0, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xDF, 0x1E,
  0xF0, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0x78, 0xF9, 0xF7, 0x9F, 0x9F, 0x79, 0xF9, 0xE7, 0x9F, 0xBE,
  0x7B, 0xFB, 0xC7, 0xBF, 0xBC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0x7F,
  0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xC7,
  0xE0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x87, 0xCF, 0x81, 0xEF,
  0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC1,
  0xF3, 0xE1, 0xF9, 0xF8, 0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xE7, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x78, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0x00, 0x30, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3E, 0x0F, 0xE0,
  0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x08, 0x00, 0x7C, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x40, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 12, 8, 13, 3, -21 },
  { 37, 16, 21, 15, 0, -21 },
  { 79, 14, 24, 14, 0, -22 },
  { 121, 20, 21, 23, 2, -21 },
  { 174, 17, 21, 17, 0, -21 },
  { 219, 6, 8, 7, 3, -21 },
  { 225, 11, 26, 8, 0, -21 },
  { 261, 10, 26, 8, -2, -21 },
  { 294, 12, 13, 13, 2, -22 },
  { 314, 13, 14, 15, 1, -17 },
  { 337, 8, 8, 8, -2, -4 },
  { 345, 9, 4, 9, 0, -10 },
  { 350, 5, 5, 8, 0, -5 },
  { 354, 16, 21, 12, -2, -21 },
  { 396, 13, 21, 14, 1, -21 },
  { 431, 11, 21, 14, 3, -21 },
  { 460, 15, 21, 14, -1, -21 },
  { 500, 14, 21, 14, 0, -21 },
  { 537, 14, 21, 14, 0, -21 },
  { 574, 13, 21, 14, 1, -21 },
  { 609, 14, 21, 14, 1, -21 },
  { 646, 14, 21, 14, 1, -21 },
  { 683, 14, 21, 14, 0, -21 },
  { 720, 14, 21, 14, 0, -21 },
  { 757, 8, 16, 8, 0, -16 },
  { 773, 10, 20, 8, -2, -16 },
  { 798, 13, 15, 15, 1, -18 },
  { 823, 13, 10, 15, 1, -15 },
  { 840, 13, 15, 15, 1, -18 },
  { 865, 11, 21, 11, 1, -21 },
  { 894, 20, 23, 20, 1, -21 },
  { 952, 16, 21, 15, -2, -21 },
  { 994, 15, 21, 15, 0, -21 },
  { 1034, 14, 21, 14, 1, -21 },
  { 1071, 16, 21, 16, 0, -21 },
  { 1113, 14, 21, 12, 0, -21 },
  { 1150, 14, 21, 12, 0, -21 },
  { 1187, 16, 21, 16, 1, -21 },
  { 1229, 18, 21, 16, 0, -21 },
  { 1277, 14, 21, 11, -1, -21 },
  { 1314, 14, 28, 8, -5, -21 },
  { 1363, 18, 21, 15, 0, -21 },
  { 1411, 10, 21, 12, 0, -21 },
  { 1438, 23, 21, 22, 0, -21 },
  { 1499, 19, 21, 18, 0, -21 },
  { 1549, 16, 21, 17, 1, -21 },
  { 1591, 15, 21, 14, 0, -21 },
  { 1631, 16, 26, 17, 1, -21 },
  { 1683, 15, 21, 15, 0, -21 },
  { 1723, 15, 21, 13, -1, -21 },
  { 1763, 13, 21, 12, 2, -21 },
  { 1798, 16, 21, 16, 1, -21 },
  { 1840, 15, 21, 15, 3, -21 },
  { 1880, 22, 21, 22, 2, -21 },
  { 1938, 19, 21, 15, -2, -21 },
  { 1988, 14, 21, 14, 3, -21 },
  { 2025, 16, 21, 13, -1, -21 },
  { 2067, 12, 26, 8, -1, -21 },
  { 2106, 7, 21, 12, 3, -21 },
  { 2125, 12, 26, 8, -2, -21 },
  { 2164, 15, 14, 13, -1, -21 },
  { 2191, 12, 3, 11, -3, 2 },
  { 2196, 6, 4, 10, 4, -22 },
  { 2199, 15, 16, 14, 0, -16 },
  { 2229, 14, 22, 14, 0, -22 },
  { 2268, 11, 16, 12, 1, -16 },
  { 2290, 16, 22, 14, 0, -22 },
  { 2334, 13, 16, 13, 0, -16 },
  { 2360, 15, 29, 9, -3, -22 },
  { 2415, 16, 23, 14, -1, -16 },
  { 2461, 14, 22, 14, 0, -22 },
  { 2500, 9, 23, 7, 0, -23 },
  { 2526, 13, 30, 7, -4, -23 },
  { 2575, 16, 22, 14, 0, -22 },
  { 2619, 9, 22, 7, 0, -22 },
  { 2644, 21, 16, 21, 0, -16 },
  { 2686, 14, 16, 14, 0, -16 },
  { 2714, 12, 16, 14, 1, -16 },
  { 2738, 16, 23, 14, -2, -16 },
  { 2784, 15, 23, 14, 0, -16 },
  { 2828, 12, 16, 10, 0, -16 },
  { 2852, 12, 16, 11, 0, -16 },
  { 2876, 10, 19, 10, 1, -19 },
  { 2900, 14, 16, 14, 1, -16 },
  { 2928, 13, 16, 13, 2, -16 },
  { 2954, 20, 16, 20, 1, -16 },
  { 2994, 17, 16, 13, -2, -16 },
  { 3028, 17, 23, 13, -2, -16 },
  { 3077, 13, 16, 11, -1, -16 },
  { 3103, 12, 26, 10, 0, -21 },
  { 3142, 4, 29, 11, 4, -22 },
  { 3157, 12, 26, 10, -2, -21 },
  { 3196, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC29PT7B_H_
