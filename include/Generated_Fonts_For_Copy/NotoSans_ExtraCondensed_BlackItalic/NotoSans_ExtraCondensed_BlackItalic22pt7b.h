#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x00, 0x06,
  0x1E, 0x3C, 0x70, 0x7F, 0xBB, 0xDD, 0xFE, 0xEE, 0x77, 0x38, 0x07, 0x70,
  0x77, 0x06, 0x60, 0xEE, 0x3F, 0xF3, 0xFF, 0x7F, 0xF1, 0xDC, 0x19, 0x87,
  0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0x07, 0x70, 0x76, 0x0E, 0xE0, 0x01, 0x00,
  0x20, 0x3F, 0x0F, 0xF3, 0xFC, 0x74, 0x8E, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xC4, 0xB8, 0xFF, 0x3F, 0xC3, 0xF0, 0x08, 0x02, 0x00, 0x1C,
  0x1C, 0x3E, 0x38, 0x7E, 0x38, 0x66, 0x70, 0x66, 0x60, 0xEE, 0xE0, 0xEE,
  0xCC, 0xFD, 0xDF, 0x7D, 0xBF, 0x73, 0xB7, 0x07, 0x77, 0x07, 0x77, 0x0E,
  0x76, 0x0C, 0x7E, 0x1C, 0x7E, 0x38, 0x3C, 0x03, 0x80, 0x7F, 0x07, 0xF8,
  0x39, 0xC1, 0xDE, 0x0F, 0xE0, 0x7E, 0x03, 0xEF, 0x3F, 0x7B, 0xFF, 0x9D,
  0xFD, 0xEF, 0xCF, 0x3C, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7B, 0x9D, 0xEE,
  0x70, 0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x0F, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C,
  0x38, 0x78, 0xF0, 0x0E, 0x03, 0x86, 0xE1, 0xFE, 0xFF, 0x87, 0xF3, 0xE1,
  0xFC, 0x37, 0x84, 0x80, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF7,
  0xE0, 0x7F, 0xFE, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0x77, 0xBB, 0x9F, 0xCF, 0xE7,
  0xF7, 0xF3, 0xF9, 0xFC, 0xEE, 0xF7, 0xF3, 0xF0, 0xF0, 0x07, 0x0F, 0x1F,
  0x3F, 0x7F, 0xFE, 0x6E, 0x5E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x78, 0x03, 0xC1, 0xFC, 0x7F, 0x86, 0xF0, 0x8E, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0x9F, 0xE7, 0xFC, 0x0F,
  0x83, 0xF8, 0x7F, 0x8C, 0xF0, 0x1C, 0x07, 0x87, 0xE0, 0xF8, 0x1F, 0x01,
  0xF0, 0x1E, 0x03, 0xC8, 0x79, 0xFF, 0x3F, 0xC7, 0xE0, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0xFC, 0x1F, 0x86, 0xE1, 0xDC, 0x37, 0x8C, 0xF3, 0xFF,
  0x7F, 0xEF, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x03, 0xC8,
  0x79, 0xFE, 0x3F, 0xC7, 0xF0, 0x07, 0xC3, 0xF1, 0xFC, 0xF0, 0x78, 0x1C,
  0x07, 0xF3, 0xFE, 0xFF, 0xBD, 0xEE, 0x7B, 0x9E, 0xE7, 0x3F, 0xCF, 0xE1,
  0xF0, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0x07,
  0x81, 0xF8, 0x7F, 0x9E, 0xF3, 0xDE, 0x7B, 0x87, 0xE0, 0xF8, 0x3F, 0x8F,
  0xF1, 0xCE, 0x79, 0xCF, 0x39, 0xFF, 0x1F, 0xC1, 0xF0, 0x07, 0x83, 0xF8,
  0x7F, 0x1E, 0xE3, 0x9E, 0x73, 0x9E, 0x73, 0xDE, 0x7F, 0xC7, 0xF8, 0x6E,
  0x03, 0xC0, 0xF1, 0xFE, 0x3F, 0x87, 0xE0, 0x3C, 0xF3, 0xCE, 0x00, 0x00,
  0x00, 0x73, 0xCF, 0x38, 0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x83, 0xC7, 0xEF, 0xEF, 0x87,
  0xC1, 0xF8, 0x3F, 0x07, 0x80, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF3,
  0xF3, 0xF0, 0xF0, 0x30, 0x08, 0x00, 0x1E, 0x7F, 0x7F, 0x67, 0x07, 0x0F,
  0x1E, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x06, 0x19, 0xF6, 0x3B, 0xF7, 0x37, 0x77,
  0x76, 0x76, 0x66, 0x66, 0x6E, 0x66, 0x6E, 0xEE, 0xEF, 0xFC, 0xE7, 0xF8,
  0x60, 0x00, 0x70, 0x10, 0x7D, 0xE0, 0x3F, 0xE0, 0x07, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xB8, 0xF7, 0x1E, 0xE3, 0x9C,
  0xFF, 0x9F, 0xF7, 0xFE, 0xF1, 0xFC, 0x3F, 0x87, 0x1F, 0x81, 0xFE, 0x1F,
  0xE1, 0xDF, 0x3C, 0xF3, 0xDE, 0x3F, 0xE3, 0xF8, 0x7F, 0xC7, 0xBC, 0x79,
  0xC7, 0xBC, 0x73, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0x07, 0x83, 0xFC, 0xFF,
  0x1E, 0x47, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x11, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x9E,
  0x77, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C,
  0x0F, 0x03, 0xF8, 0xFE, 0x7F, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3F, 0xCF,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xFE,
  0x7F, 0x1F, 0xC7, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xE0,
  0xFF, 0x1F, 0xE3, 0xE6, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x7E, 0xF7, 0xCF,
  0x7C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xF8, 0x7F, 0x83, 0xF0, 0x1E, 0x38,
  0xF3, 0xC7, 0x1E, 0x38, 0xF3, 0xC7, 0x1E, 0x38, 0xFF, 0xC7, 0xFE, 0x7F,
  0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0xE3, 0xC7, 0x1E, 0x78,
  0x1F, 0xE3, 0xFC, 0x3F, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x7C, 0x3F, 0xC7, 0xF8, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x2F, 0x0F, 0xC3, 0xE0, 0xF0,
  0x00, 0x1E, 0x7C, 0x79, 0xE1, 0xCF, 0x07, 0x78, 0x3D, 0xE0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x73, 0x83,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFD, 0xFC,
  0x7E, 0xFE, 0x7F, 0x7E, 0x3F, 0xF7, 0x1F, 0xFF, 0x8E, 0xFB, 0xC7, 0x7D,
  0xE7, 0xBC, 0xE3, 0xDE, 0x71, 0xCF, 0x78, 0x1E, 0x1C, 0x78, 0x71, 0xF3,
  0xC7, 0xCF, 0x3F, 0x38, 0xFC, 0xE3, 0xF7, 0x8F, 0xFE, 0x7F, 0xF1, 0xEF,
  0xC7, 0x3F, 0x1C, 0xFC, 0x73, 0xF3, 0xCF, 0x8F, 0x1E, 0x38, 0x78, 0x07,
  0x81, 0xFE, 0x3F, 0xE3, 0xDE, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0E, 0xF1,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1F,
  0x83, 0xF8, 0x7F, 0x8E, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xDF, 0x7F, 0xCF,
  0xF1, 0xF8, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xFE,
  0x3F, 0xE3, 0xDE, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x1F, 0x83, 0xFC, 0x7F, 0x8E, 0xF3, 0xCE, 0x7B, 0xCF,
  0x79, 0xFF, 0x7F, 0xCF, 0xE1, 0xFE, 0x3F, 0xC7, 0x79, 0xE7, 0xBC, 0xF7,
  0x9E, 0x07, 0x83, 0xFC, 0xFF, 0x1F, 0xE3, 0xC4, 0x78, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1E, 0x43, 0xCC, 0xF9, 0xFE, 0x3F, 0xC7, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x8E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7,
  0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0x79, 0xEF, 0x3D,
  0xEF, 0x3D, 0xE7, 0xB8, 0xFF, 0x1F, 0xC3, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0x78, 0xE3, 0xBC, 0xF3, 0xDC, 0x79, 0xEE, 0x7C, 0xE7,
  0x3E, 0xF3, 0x9F, 0x71, 0xDF, 0x78, 0xEF, 0xBC, 0x7F, 0xDC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xEF, 0x81, 0xE7, 0xC1, 0xF3,
  0xE0, 0x1E, 0x3C, 0x79, 0xE0, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xEF, 0x07, 0x9C, 0x3C, 0x78, 0xF1, 0xFE, 0x7B, 0xCF, 0x3B, 0xC7, 0x70,
  0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0xFC,
  0xFF, 0x8F, 0xF8, 0x0F, 0x87, 0xC3, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x7C, 0x3E,
  0x1F, 0x00, 0xE7, 0x3C, 0xE7, 0x39, 0xCE, 0x73, 0x8E, 0x73, 0x9C, 0xE7,
  0x0F, 0xC3, 0xE0, 0xF8, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x1F, 0x07, 0xC3,
  0xE0, 0x03, 0x01, 0xC0, 0x78, 0x3E, 0x0F, 0x87, 0xE3, 0xB8, 0xE7, 0x71,
  0xFC, 0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0x9E, 0x70, 0x1E, 0xE7,
  0xFC, 0xFF, 0x3D, 0xE7, 0xBC, 0xE7, 0xBC, 0xF7, 0x9C, 0xF7, 0x9F, 0xF1,
  0xFE, 0x3D, 0xC0, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0xF3, 0xFC,
  0xFF, 0x39, 0xDE, 0x77, 0x9D, 0xCF, 0x73, 0xFC, 0xEF, 0xFB, 0xFC, 0xEE,
  0x00, 0x1F, 0x9F, 0xCF, 0xCF, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF2, 0x3F,
  0x1F, 0x87, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE1, 0xFE,
  0x3F, 0xE3, 0xFC, 0x7B, 0xC7, 0xBC, 0x73, 0xCF, 0x3C, 0xF3, 0x8F, 0x78,
  0xFF, 0x87, 0xF8, 0x7B, 0x80, 0x0F, 0x8F, 0xF3, 0xFD, 0xE7, 0x77, 0xDF,
  0xEF, 0xE3, 0xC0, 0xF0, 0x9F, 0xC7, 0xF0, 0xFC, 0x01, 0xE0, 0x7C, 0x1F,
  0x83, 0xC0, 0x70, 0x1F, 0x87, 0xF0, 0xFC, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0x71, 0xFF, 0x1F, 0xE3, 0xCE, 0x3D, 0xE3, 0x9E,
  0x79, 0xE7, 0x9C, 0x7B, 0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x03, 0x88, 0x78,
  0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0xF3, 0xFC, 0xFF, 0x39, 0xDE, 0x77, 0xBD, 0xCF, 0x73, 0xFC, 0xEF, 0x3B,
  0xDE, 0xE7, 0x80, 0x0C, 0x3C, 0x70, 0x40, 0x07, 0x8E, 0x1C, 0x38, 0xF1,
  0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xE0, 0x01, 0x80, 0xF0, 0x38, 0x04, 0x00,
  0x01, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xCF, 0x39, 0xE3, 0xBC, 0x3F, 0x87,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0x8F, 0x78, 0xE3, 0xC0,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x1E,
  0x3C, 0x78, 0xE0, 0x3B, 0xDE, 0x3F, 0xFF, 0x3F, 0xFF, 0x39, 0xCE, 0x79,
  0xCE, 0x7B, 0xCE, 0x73, 0xDE, 0x73, 0x9E, 0xF3, 0x9C, 0xF7, 0x9C, 0xF7,
  0x9C, 0xE7, 0xBC, 0x3B, 0xCF, 0xF3, 0xFC, 0xE7, 0x79, 0xDE, 0xF7, 0x3D,
  0xCF, 0xF3, 0xBC, 0xEF, 0x7B, 0x9E, 0x0F, 0x8F, 0xF3, 0xFD, 0xE7, 0x79,
  0xDC, 0xF7, 0x3F, 0xCF, 0xF3, 0x9F, 0xE7, 0xF0, 0xF8, 0x1D, 0xE3, 0xFC,
  0x7F, 0x8E, 0x73, 0xCE, 0x79, 0xCE, 0x79, 0xCF, 0x79, 0xCF, 0xF9, 0xFE,
  0x3B, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xFC,
  0xFF, 0x3C, 0xE7, 0xBC, 0xE7, 0xBC, 0xF7, 0x9C, 0xF7, 0x9F, 0xF1, 0xFE,
  0x3F, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x3B, 0x9F, 0x8F,
  0xC7, 0xA7, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x00, 0x1F,
  0x9F, 0x9E, 0xCF, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x8F, 0x7F, 0x3F, 0x9F,
  0x80, 0x1C, 0x38, 0xE3, 0xFF, 0xFF, 0xDC, 0x38, 0x71, 0xE3, 0xC7, 0x0F,
  0x9F, 0x1E, 0x00, 0x3D, 0xE7, 0x3C, 0xE7, 0xBC, 0xE7, 0x9C, 0xF7, 0x9C,
  0xF3, 0x9C, 0xF7, 0x9F, 0xF1, 0xFE, 0x3D, 0xC0, 0xF3, 0xFC, 0xFF, 0x79,
  0xDE, 0x77, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF7,
  0xDF, 0xEF, 0xBB, 0xDF, 0x77, 0xFD, 0xEF, 0xFB, 0x9D, 0xB7, 0x3F, 0x7C,
  0x7F, 0xF8, 0xFB, 0xF1, 0xF7, 0xC3, 0xEF, 0x87, 0x9E, 0x00, 0x3C, 0xF1,
  0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x87,
  0xB8, 0x7B, 0x8F, 0x3C, 0x3C, 0xF3, 0xCE, 0x1D, 0xE1, 0xDE, 0x1D, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0x1E, 0x0F,
  0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1F, 0xEF, 0xF3, 0xFC, 0x03, 0x83, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x38, 0x7C, 0x7C, 0x3C, 0x0F, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x1E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E,
  0x0F, 0x07, 0x1F, 0x1F, 0x3C, 0x3C, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x70,
  0x7F, 0xFF, 0xFE, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 12, 16, 12, 0, -16 },
  { 46, 11, 18, 10, 0, -17 },
  { 71, 16, 16, 17, 1, -16 },
  { 103, 13, 16, 13, 0, -16 },
  { 129, 5, 6, 5, 2, -16 },
  { 133, 8, 19, 6, 0, -16 },
  { 152, 8, 19, 6, -2, -16 },
  { 171, 10, 10, 10, 1, -17 },
  { 184, 9, 11, 11, 1, -13 },
  { 197, 5, 6, 6, -1, -3 },
  { 201, 7, 4, 7, 0, -8 },
  { 205, 4, 4, 6, 0, -4 },
  { 207, 12, 16, 9, -1, -16 },
  { 231, 9, 16, 10, 1, -16 },
  { 249, 8, 16, 10, 2, -16 },
  { 265, 11, 16, 10, -1, -16 },
  { 287, 11, 16, 10, 0, -16 },
  { 309, 11, 16, 10, 0, -16 },
  { 331, 11, 16, 10, 0, -16 },
  { 353, 10, 16, 10, 1, -16 },
  { 373, 11, 16, 10, 1, -16 },
  { 395, 11, 16, 10, 0, -16 },
  { 417, 11, 16, 10, 0, -16 },
  { 439, 6, 12, 6, 0, -12 },
  { 448, 7, 15, 6, -1, -12 },
  { 462, 9, 11, 11, 1, -13 },
  { 475, 9, 8, 11, 1, -12 },
  { 484, 10, 11, 11, 1, -13 },
  { 498, 8, 16, 8, 1, -16 },
  { 514, 16, 18, 16, 0, -16 },
  { 550, 11, 16, 12, -1, -16 },
  { 572, 12, 16, 11, 0, -16 },
  { 596, 11, 16, 10, 1, -16 },
  { 618, 12, 16, 12, 0, -16 },
  { 642, 10, 16, 9, 0, -16 },
  { 662, 10, 16, 9, 0, -16 },
  { 682, 12, 16, 12, 1, -16 },
  { 706, 13, 16, 12, 0, -16 },
  { 732, 11, 16, 8, -1, -16 },
  { 754, 10, 21, 6, -3, -16 },
  { 781, 14, 16, 11, 0, -16 },
  { 809, 8, 16, 9, 0, -16 },
  { 825, 17, 16, 16, 0, -16 },
  { 859, 14, 16, 13, 0, -16 },
  { 887, 12, 16, 13, 1, -16 },
  { 911, 11, 16, 11, 0, -16 },
  { 933, 12, 20, 13, 1, -16 },
  { 963, 11, 16, 11, 0, -16 },
  { 985, 11, 16, 10, 0, -16 },
  { 1007, 9, 16, 9, 2, -16 },
  { 1025, 12, 16, 12, 1, -16 },
  { 1049, 11, 16, 11, 2, -16 },
  { 1071, 17, 16, 16, 1, -16 },
  { 1105, 14, 16, 11, -1, -16 },
  { 1133, 11, 16, 11, 2, -16 },
  { 1155, 12, 16, 10, -1, -16 },
  { 1179, 9, 20, 6, -1, -16 },
  { 1202, 5, 16, 9, 2, -16 },
  { 1212, 10, 20, 6, -2, -16 },
  { 1237, 10, 11, 10, 0, -16 },
  { 1251, 9, 3, 8, -2, 1 },
  { 1255, 5, 4, 7, 3, -17 },
  { 1258, 11, 12, 11, 0, -12 },
  { 1275, 10, 17, 11, 0, -17 },
  { 1297, 9, 12, 9, 0, -12 },
  { 1311, 12, 17, 11, 0, -17 },
  { 1337, 10, 12, 10, 0, -12 },
  { 1352, 11, 22, 7, -2, -17 },
  { 1383, 12, 17, 11, -1, -12 },
  { 1409, 10, 17, 11, 0, -17 },
  { 1431, 7, 17, 6, 0, -17 },
  { 1446, 10, 22, 6, -3, -17 },
  { 1474, 12, 17, 11, 0, -17 },
  { 1500, 7, 17, 6, 0, -17 },
  { 1515, 16, 12, 16, 0, -12 },
  { 1539, 10, 12, 11, 0, -12 },
  { 1554, 10, 12, 11, 0, -12 },
  { 1569, 11, 17, 11, -1, -12 },
  { 1593, 11, 17, 11, 0, -12 },
  { 1617, 9, 12, 8, 0, -12 },
  { 1631, 9, 12, 9, 0, -12 },
  { 1645, 7, 15, 8, 1, -15 },
  { 1659, 11, 12, 11, 0, -12 },
  { 1676, 10, 12, 10, 1, -12 },
  { 1691, 15, 12, 15, 1, -12 },
  { 1714, 12, 12, 10, -1, -12 },
  { 1732, 12, 17, 10, -1, -12 },
  { 1758, 10, 12, 9, -1, -12 },
  { 1773, 9, 19, 8, 0, -16 },
  { 1795, 3, 22, 9, 3, -17 },
  { 1804, 8, 19, 8, -1, -16 },
  { 1823, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC22PT7B_H_
