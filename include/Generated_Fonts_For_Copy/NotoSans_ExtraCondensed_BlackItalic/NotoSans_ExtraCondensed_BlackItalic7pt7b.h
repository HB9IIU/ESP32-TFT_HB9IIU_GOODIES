#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5C, 0x80, 0xF8, 0x77, 0xEE, 0xC0, 0x69, 0xFC, 0x6D, 0xBA, 0x75,
  0x80, 0x76, 0x7B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80, 0x79,
  0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x25, 0x48, 0x6E, 0xDC, 0x77, 0x80,
  0x6D, 0xAE, 0x65, 0x9C, 0x2E, 0xF4, 0x69, 0x9E, 0x74, 0xEA, 0xE0, 0x72,
  0x24, 0xC0, 0x6D, 0xDE, 0x6F, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xE3,
  0x80, 0xC7, 0x00, 0x65, 0x0C, 0x3B, 0xF7, 0xD9, 0x30, 0x2D, 0xFA, 0x77,
  0xEA, 0xE0, 0x74, 0xC8, 0xE0, 0x65, 0xFA, 0xE0, 0x6B, 0xCC, 0x6B, 0xC8,
  0x74, 0xFA, 0x60, 0x55, 0xFA, 0xA0, 0x69, 0x2C, 0x24, 0xA5, 0xA0, 0x56,
  0xEA, 0xA0, 0x4B, 0x4E, 0x6B, 0xFF, 0x5B, 0x80, 0x5B, 0xBD, 0x6B, 0x00,
  0x75, 0xDB, 0xE0, 0x67, 0xE8, 0x80, 0x75, 0xDB, 0xE2, 0x67, 0xEA, 0xA0,
  0x69, 0x9C, 0xF2, 0x48, 0x55, 0xFA, 0xE0, 0xBF, 0x68, 0x5D, 0xE7, 0x96,
  0xD0, 0x76, 0x66, 0xA0, 0xBB, 0x48, 0x72, 0x4C, 0xE0, 0x6A, 0x49, 0x00,
  0xF8, 0x24, 0x95, 0x80, 0x2E, 0x80, 0xE0, 0xC0, 0x7A, 0xAE, 0x4F, 0xDE,
  0x7A, 0x60, 0x16, 0xAA, 0xE0, 0x77, 0x70, 0x36, 0x24, 0x44, 0x80, 0x7A,
  0xAE, 0xEC, 0x4F, 0xDA, 0x5E, 0x80, 0x25, 0xA4, 0xA0, 0x47, 0xEE, 0xA0,
  0x5E, 0x80, 0x7F, 0x6B, 0x60, 0x7E, 0xD0, 0x76, 0xF0, 0x7E, 0xF9, 0x00,
  0x7A, 0xAE, 0x64, 0x7A, 0x40, 0x79, 0x60, 0x5D, 0x4C, 0x7E, 0xAE, 0xFE,
  0x44, 0xED, 0x7D, 0xE0, 0xF6, 0x4A, 0xF6, 0x44, 0xC8, 0xEB, 0x60, 0x6B,
  0x6D, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 6, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 3, 6, 2, 0, -5 },
  { 20, 3, 6, 2, -1, -5 },
  { 23, 3, 3, 3, 0, -5 },
  { 25, 3, 3, 4, 0, -4 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 2, 5, 3, 1, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 4, 5, 3, 0, -5 },
  { 47, 4, 5, 3, 0, -5 },
  { 50, 3, 5, 3, 0, -5 },
  { 52, 3, 5, 3, 0, -5 },
  { 54, 2, 4, 2, 0, -4 },
  { 55, 2, 5, 2, 0, -4 },
  { 57, 3, 3, 4, 0, -4 },
  { 59, 3, 3, 4, 0, -4 },
  { 61, 3, 3, 4, 0, -4 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 5, 6, 5, 0, -5 },
  { 69, 3, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 3, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 3, 5, 3, 0, -5 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 3, 7, 2, -1, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 5, 5, 5, 0, -5 },
  { 104, 5, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 3, 0, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 3, 5, 3, 1, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 3, 5, 4, 1, -5 },
  { 129, 6, 5, 5, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 3, 5, 3, 1, -5 },
  { 138, 4, 5, 3, 0, -5 },
  { 141, 3, 6, 2, 0, -5 },
  { 144, 1, 5, 3, 1, -5 },
  { 145, 3, 6, 2, -1, -5 },
  { 148, 3, 3, 3, 0, -5 },
  { 150, 3, 1, 3, -1, 0 },
  { 151, 2, 1, 2, 1, -5 },
  { 152, 4, 4, 3, 0, -4 },
  { 154, 3, 5, 3, 0, -5 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 4, 5, 3, 0, -5 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 4, 7, 2, -1, -5 },
  { 167, 4, 6, 3, 0, -4 },
  { 170, 3, 5, 3, 0, -5 },
  { 172, 2, 5, 2, 0, -5 },
  { 174, 3, 7, 2, -1, -5 },
  { 177, 4, 5, 3, 0, -5 },
  { 180, 2, 5, 2, 0, -5 },
  { 182, 5, 4, 5, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 3, 6, 3, 0, -4 },
  { 192, 4, 6, 3, 0, -4 },
  { 195, 3, 4, 2, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 3, 5, 2, 0, -5 },
  { 201, 4, 4, 3, 0, -4 },
  { 203, 4, 4, 3, 0, -4 },
  { 205, 5, 4, 5, 0, -4 },
  { 208, 4, 4, 3, 0, -4 },
  { 210, 4, 6, 3, 0, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 3, 6, 2, 0, -5 },
  { 218, 1, 7, 3, 1, -5 },
  { 219, 2, 6, 2, 0, -5 },
  { 221, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC7PT7B_H_
