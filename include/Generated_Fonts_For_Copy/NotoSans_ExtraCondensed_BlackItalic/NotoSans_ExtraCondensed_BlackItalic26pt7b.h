#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x40, 0x00, 0x20, 0x78, 0xF8, 0xF0, 0xF0, 0x7D, 0xEF, 0x3D, 0xEF,
  0xBD, 0xE7, 0xBC, 0xE7, 0xBC, 0xF0, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0,
  0x39, 0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x0E, 0x70, 0x1D,
  0xC0, 0x73, 0x83, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1D, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xDC, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xF8, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x74, 0x87, 0xA0, 0x1F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3E, 0x03, 0xF1, 0x1F, 0x8F, 0xFC, 0x7F, 0xC7, 0xFC, 0x1F,
  0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x0E, 0x07, 0x83, 0xE0, 0xE0, 0xFE,
  0x38, 0x3D, 0xC7, 0x07, 0x39, 0xC0, 0xEF, 0x78, 0x1D, 0xCE, 0x07, 0xBB,
  0xC0, 0xF7, 0x77, 0xCF, 0xDD, 0xFD, 0xF3, 0xBB, 0x9C, 0xEF, 0x70, 0x1D,
  0xCE, 0x07, 0x39, 0xC1, 0xE7, 0x78, 0x38, 0xEE, 0x0F, 0x1F, 0xC1, 0xC3,
  0xF0, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC1, 0x1F, 0x9E,
  0x3F, 0xDE, 0x7F, 0xFC, 0x7B, 0xFC, 0xFB, 0xF8, 0xF9, 0xF8, 0xFB, 0xF0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x7C, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x00,
  0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC0, 0x0F, 0x01, 0xE1, 0x38, 0x7F,
  0x2F, 0xFD, 0xFF, 0x87, 0xF9, 0xF8, 0x7F, 0x1E, 0xF0, 0xCE, 0x11, 0x00,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E,
  0x78, 0x7F, 0x7E, 0x7E, 0xFE, 0x23, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x9F,
  0xF3, 0xDE, 0xFB, 0xDE, 0x7B, 0xCF, 0x79, 0xFF, 0x3F, 0xC7, 0xF9, 0xFF,
  0x3D, 0xE7, 0xBD, 0xF7, 0xFC, 0xFF, 0x1F, 0xE1, 0xF0, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0x7F, 0x3F, 0x9F, 0xEF, 0xF9, 0xDE, 0x2F, 0x83, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0x01, 0xE0,
  0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xE7, 0x82, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x3F, 0xF8, 0x03, 0xC0, 0xFF, 0x1F, 0xF1, 0xFF, 0x08,
  0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x83, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1D,
  0xE1, 0xDF, 0x0E, 0xF0, 0xE7, 0x8F, 0xFF, 0x7F, 0xFB, 0xFF, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x03,
  0xC0, 0x1E, 0x01, 0xF2, 0x0F, 0x9F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0,
  0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xBC,
  0x7F, 0xCF, 0xFE, 0xFB, 0xEF, 0xBE, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0xFC,
  0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC3,
  0xFC, 0x1F, 0xC0, 0x7C, 0x0F, 0xF0, 0xFF, 0xC7, 0x9E, 0x7C, 0xF3, 0xC7,
  0x9F, 0x7C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0xC0, 0xFE, 0x1F, 0xF1,
  0xFF, 0x3E, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFE, 0x1D, 0xE0, 0x3E, 0x03, 0xCC, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00,
  0x04, 0x3C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x83, 0xCF, 0x9F,
  0x3C, 0x00, 0x01, 0x03, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x00,
  0x00, 0x20, 0x0C, 0x0F, 0x87, 0xF3, 0xFD, 0xFE, 0x3E, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x0E, 0x00, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0xFF, 0x3F, 0xCF, 0xF0, 0xFC, 0x0F,
  0x00, 0x80, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0x63, 0xC0, 0xF0, 0x78,
  0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0xE0, 0x40, 0x00, 0x02, 0x03, 0xC0, 0xF8,
  0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF1,
  0xC0, 0x39, 0xCF, 0xFD, 0xCF, 0xE6, 0xE7, 0x73, 0x67, 0x39, 0xF3, 0x9D,
  0xFB, 0x9C, 0xFD, 0xCE, 0x7C, 0xE7, 0x76, 0x77, 0xFB, 0x3F, 0xF9, 0xCE,
  0x78, 0xE0, 0x00, 0x78, 0x08, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D, 0xF0, 0xFF, 0x83, 0xC0, 0x0F, 0x80,
  0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0x79, 0xF1, 0xE7, 0x8F, 0xBE,
  0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x9F,
  0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xC3,
  0xFC, 0x3F, 0xE3, 0xE2, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE1, 0x1F, 0xF0, 0xFF, 0x83,
  0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C,
  0x79, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xDF, 0x1E,
  0x7C, 0xF9, 0xE3, 0xE7, 0x9F, 0x1F, 0xF8, 0xFF, 0xE3, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0x10, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x79, 0xFB, 0xE7, 0xEF, 0xBF, 0x3E, 0xFC, 0xF0, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0x1F, 0x0F,
  0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F,
  0xF8, 0x7F, 0x87, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x1F, 0x0F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7B, 0xE0,
  0x79, 0xE0, 0x79, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0x0F, 0x07,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xF0, 0xF8,
  0x3F, 0x1F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE3, 0xFD, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xBC, 0x7B, 0xFB, 0xC7, 0xBF, 0x7C, 0x7B, 0xF7, 0x87, 0xBE, 0x78,
  0xF3, 0xE7, 0x8F, 0x3C, 0xF8, 0xF3, 0xCF, 0x00, 0x0F, 0x87, 0x87, 0xC7,
  0xC7, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0xF0, 0xFE, 0x78, 0x7F, 0x7C, 0x7F,
  0xBC, 0x3F, 0xDE, 0x1F, 0xEF, 0x0F, 0x77, 0x8F, 0xBF, 0x87, 0x9F, 0xC3,
  0xCF, 0xE1, 0xE7, 0xF0, 0xF3, 0xF8, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E,
  0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF1, 0xF7,
  0xC7, 0xDE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x1E, 0xF0, 0xFB,
  0xC3, 0xEF, 0x9F, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7F, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0xDF,
  0x3C, 0xF9, 0xFF, 0x8F, 0xFC, 0xFF, 0xC7, 0xF8, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFF, 0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xBE, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF, 0x9F, 0x3F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x8F,
  0xBE, 0x3D, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xEF, 0x87,
  0xBE, 0x1E, 0x78, 0xF9, 0xE3, 0xE7, 0xCF, 0x1F, 0x00, 0x03, 0xE0, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE3, 0xE6, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE3, 0x0F, 0x1F, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7,
  0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0x78, 0xF9, 0xE3,
  0xC7, 0x8F, 0x3E, 0x3C, 0xF9, 0xF3, 0xC7, 0xCF, 0x1E, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x7F, 0xE1, 0xEF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xFC,
  0x1F, 0xE0, 0x77, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0xF1, 0xFF, 0x8F, 0x1E, 0xF9, 0xF1, 0xEF, 0x1F,
  0x3E, 0xF1, 0xF3, 0xCF, 0x3F, 0x3C, 0xF3, 0xF7, 0x8F, 0x7F, 0x78, 0xF7,
  0xFF, 0x8F, 0x7E, 0xF0, 0xFF, 0xEF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xFB, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D,
  0xF0, 0x3E, 0xF8, 0x3E, 0x3C, 0x3E, 0x1F, 0x00, 0xF8, 0xFB, 0xC7, 0xDE,
  0x7C, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xE3, 0x8E, 0x3C,
  0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0xC0,
  0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x70, 0xE3,
  0xCF, 0x1E, 0xF0, 0xFF, 0x07, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF7,
  0xDE, 0x70, 0x06, 0x00, 0xFB, 0xC7, 0xFE, 0x7F, 0xE3, 0xCF, 0x3E, 0x79,
  0xE3, 0xCF, 0x3E, 0x79, 0xE7, 0xCF, 0x3E, 0x79, 0xF7, 0xCF, 0xFE, 0x3F,
  0xE1, 0xE7, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xEC,
  0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x8F,
  0x79, 0xF7, 0x9E, 0xFB, 0xEF, 0xFC, 0xFF, 0xCE, 0x78, 0x03, 0x01, 0xFC,
  0x7F, 0x9F, 0xE3, 0xC4, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE2,
  0x3D, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x19, 0xE1, 0xF7, 0x87, 0xFE, 0x3F, 0xF0, 0xF3, 0xC7,
  0xCF, 0x1E, 0x3C, 0x79, 0xF1, 0xE7, 0x8F, 0x9E, 0x3E, 0x78, 0xFB, 0xE3,
  0xFF, 0x07, 0xFC, 0x1E, 0x70, 0x03, 0x00, 0xFE, 0x1F, 0xE3, 0xFF, 0x3C,
  0xF7, 0x8F, 0x7F, 0xE7, 0xFC, 0x7F, 0x8F, 0x80, 0xF8, 0x0F, 0x8C, 0x7F,
  0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x0F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0B, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x03, 0x00, 0x1E, 0xF0, 0xFF, 0xC7, 0xFE, 0x1E, 0x78, 0xF9,
  0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF1, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x7F,
  0xF0, 0xFF, 0x83, 0xDE, 0x00, 0x78, 0x03, 0xE3, 0x1F, 0x0F, 0xFC, 0x3F,
  0xE0, 0x7F, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xEC,
  0x1D, 0xF3, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x9F,
  0x79, 0xE7, 0x9E, 0xF9, 0xEF, 0x3E, 0xF3, 0xCF, 0x3C, 0x0F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x3F,
  0x07, 0xE0, 0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x11, 0xE7, 0x8F, 0x3E, 0x3D, 0xF0, 0xF7, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF,
  0x8F, 0x3E, 0x3C, 0x78, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0,
  0x00, 0x41, 0x07, 0x7D, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0xFB, 0xCF,
  0x3C, 0xF7, 0xCF, 0x3D, 0xE7, 0xCF, 0x79, 0xE7, 0xDE, 0x79, 0xE7, 0x9E,
  0x7B, 0xE7, 0x9E, 0xF3, 0xE7, 0xBC, 0xF3, 0xEF, 0x3C, 0xF0, 0x00, 0xC1,
  0xDF, 0x3F, 0xF3, 0xFF, 0x3E, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0x79, 0xF7,
  0x9E, 0x79, 0xEF, 0x9E, 0xF3, 0xEF, 0x3C, 0xF3, 0xC0, 0x03, 0x80, 0xFE,
  0x1F, 0xE3, 0xFF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x8F, 0x79, 0xFF, 0x9E,
  0xF9, 0xE7, 0xBE, 0x7F, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x10, 0x1D, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x79, 0xF1, 0xE7, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xDE, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x7B,
  0xC7, 0xFE, 0x7F, 0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE7,
  0xCF, 0x3E, 0x79, 0xF7, 0xCF, 0xFE, 0x3F, 0xE1, 0xEF, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x63, 0xB8, 0xFF,
  0x1F, 0xE3, 0xF8, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x06, 0x07, 0xF3, 0xFC, 0xFF, 0x7C, 0x9F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFB, 0x3E, 0xFF, 0x3F, 0xCF, 0xE0,
  0x0E, 0x0F, 0x07, 0x0F, 0xFF, 0xF7, 0xF9, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1E, 0x0F, 0x07, 0xD3, 0xF9, 0xFC, 0x7E, 0x00, 0x3E, 0x79, 0xE3, 0xCF,
  0x3E, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xCF,
  0x3F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3E, 0xE0, 0xF1, 0xFE, 0x7B, 0xCF, 0x7B,
  0xEF, 0x79, 0xEF, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x00, 0x79, 0xF3, 0xDE, 0xFD, 0xE7, 0xBE, 0x79, 0xFF, 0xBE,
  0x77, 0xEF, 0x3D, 0xFB, 0xCF, 0xFF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFC, 0x3F,
  0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x00, 0x1E,
  0x7C, 0x79, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x79, 0xE3, 0xE7, 0x80,
  0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE2, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0x00,
  0x60, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07,
  0xC1, 0xF8, 0x3C, 0x0F, 0x81, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x00, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x80,
  0xF0, 0x7C, 0x1F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3C, 0x00, 0x30, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 11, 7, 12, 2, -19 },
  { 30, 15, 19, 14, 0, -19 },
  { 66, 13, 22, 12, 0, -20 },
  { 102, 19, 19, 21, 1, -19 },
  { 148, 16, 19, 16, 0, -19 },
  { 186, 6, 7, 6, 2, -19 },
  { 192, 10, 23, 7, 0, -19 },
  { 221, 9, 23, 7, -2, -19 },
  { 247, 11, 12, 11, 2, -20 },
  { 264, 11, 13, 13, 1, -16 },
  { 282, 7, 8, 7, -2, -4 },
  { 289, 8, 4, 8, 0, -9 },
  { 293, 5, 5, 7, 0, -5 },
  { 297, 14, 19, 10, -1, -19 },
  { 331, 11, 19, 12, 1, -19 },
  { 358, 10, 19, 12, 2, -19 },
  { 382, 13, 19, 12, -1, -19 },
  { 413, 12, 19, 12, 0, -19 },
  { 442, 13, 19, 12, 0, -19 },
  { 473, 13, 19, 12, 0, -19 },
  { 504, 12, 19, 12, 1, -19 },
  { 533, 13, 19, 12, 1, -19 },
  { 564, 13, 19, 12, 0, -19 },
  { 595, 12, 19, 12, 0, -19 },
  { 624, 7, 15, 7, 0, -15 },
  { 638, 9, 19, 7, -2, -15 },
  { 660, 11, 13, 13, 1, -16 },
  { 678, 11, 9, 13, 1, -14 },
  { 691, 12, 13, 13, 1, -16 },
  { 711, 10, 19, 10, 1, -19 },
  { 735, 17, 21, 18, 1, -19 },
  { 780, 14, 19, 14, -2, -19 },
  { 814, 14, 19, 13, 0, -19 },
  { 848, 13, 19, 12, 1, -19 },
  { 879, 14, 19, 14, 0, -19 },
  { 913, 12, 19, 11, 0, -19 },
  { 942, 12, 19, 11, 0, -19 },
  { 971, 14, 19, 14, 1, -19 },
  { 1005, 16, 19, 15, 0, -19 },
  { 1043, 13, 19, 10, -1, -19 },
  { 1074, 12, 25, 7, -4, -19 },
  { 1112, 16, 19, 13, 0, -19 },
  { 1150, 9, 19, 10, 0, -19 },
  { 1172, 20, 19, 19, 0, -19 },
  { 1220, 17, 19, 16, 0, -19 },
  { 1261, 14, 19, 15, 1, -19 },
  { 1295, 13, 19, 13, 0, -19 },
  { 1326, 14, 23, 15, 1, -19 },
  { 1367, 14, 19, 13, 0, -19 },
  { 1401, 13, 19, 11, 0, -19 },
  { 1432, 11, 19, 11, 2, -19 },
  { 1459, 14, 19, 14, 1, -19 },
  { 1493, 14, 19, 14, 2, -19 },
  { 1527, 20, 19, 19, 2, -19 },
  { 1575, 17, 19, 13, -2, -19 },
  { 1616, 13, 19, 13, 2, -19 },
  { 1647, 14, 19, 11, -1, -19 },
  { 1681, 11, 23, 7, -1, -19 },
  { 1713, 6, 19, 10, 3, -19 },
  { 1728, 11, 23, 7, -2, -19 },
  { 1760, 13, 13, 12, -1, -19 },
  { 1782, 11, 3, 10, -3, 2 },
  { 1787, 5, 4, 9, 4, -20 },
  { 1790, 13, 15, 13, 0, -15 },
  { 1815, 12, 20, 13, 0, -20 },
  { 1845, 11, 15, 10, 0, -15 },
  { 1866, 14, 20, 13, 0, -20 },
  { 1901, 12, 15, 12, 0, -15 },
  { 1924, 14, 26, 8, -3, -20 },
  { 1970, 14, 21, 13, -1, -15 },
  { 2007, 12, 20, 13, 0, -20 },
  { 2037, 8, 20, 7, 0, -20 },
  { 2057, 11, 26, 7, -3, -20 },
  { 2093, 14, 20, 13, 0, -20 },
  { 2128, 8, 20, 7, 0, -20 },
  { 2148, 18, 15, 19, 0, -15 },
  { 2182, 12, 15, 13, 0, -15 },
  { 2205, 12, 15, 12, 0, -15 },
  { 2228, 14, 21, 13, -2, -15 },
  { 2265, 13, 21, 13, 0, -15 },
  { 2300, 11, 15, 9, 0, -15 },
  { 2321, 10, 15, 10, 0, -15 },
  { 2340, 9, 17, 9, 1, -17 },
  { 2360, 13, 14, 13, 0, -14 },
  { 2383, 11, 14, 12, 2, -14 },
  { 2403, 18, 14, 18, 1, -14 },
  { 2435, 14, 14, 12, -1, -14 },
  { 2460, 15, 20, 12, -2, -14 },
  { 2498, 12, 14, 10, -1, -14 },
  { 2519, 11, 23, 9, 0, -19 },
  { 2551, 4, 26, 10, 3, -20 },
  { 2564, 11, 23, 9, -2, -19 },
  { 2596, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC26PT7B_H_
