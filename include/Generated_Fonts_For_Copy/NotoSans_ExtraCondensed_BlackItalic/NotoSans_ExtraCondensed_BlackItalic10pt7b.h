#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x21, 0xB0, 0xFF, 0x38, 0xA7, 0xD4, 0xF9, 0xCE, 0x00, 0x11,
  0xDC, 0xC7, 0x1B, 0xCC, 0x40, 0xED, 0x53, 0xC7, 0xF2, 0xED, 0xB3, 0x00,
  0x39, 0xE7, 0x1F, 0xFB, 0x6F, 0x80, 0xF0, 0x36, 0x44, 0xCC, 0xCC, 0xC0,
  0x33, 0x33, 0x22, 0x64, 0xC0, 0x6F, 0xFE, 0xA0, 0x21, 0x3E, 0x42, 0x00,
  0x78, 0xE0, 0xF0, 0x0C, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0x3B, 0xD7, 0xBD,
  0x79, 0x80, 0x36, 0xA6, 0x66, 0x40, 0x7A, 0xC4, 0x66, 0x63, 0xC0, 0x7A,
  0xC4, 0xE3, 0x5B, 0x80, 0x19, 0x9C, 0xEF, 0xF8, 0x80, 0x3B, 0x1C, 0xE1,
  0x5B, 0x80, 0x3B, 0x15, 0xED, 0x79, 0xC0, 0x78, 0xC4, 0x62, 0x33, 0x00,
  0x3B, 0xDC, 0xED, 0x6B, 0xC0, 0x73, 0xD6, 0xF5, 0x1B, 0x80, 0x4C, 0x0D,
  0x80, 0x23, 0x00, 0x06, 0xC0, 0x0B, 0xB8, 0x70, 0x80, 0xF8, 0x3E, 0xC3,
  0x87, 0xC8, 0x00, 0x75, 0x36, 0x04, 0xC0, 0x3C, 0xC5, 0x7F, 0x5A, 0xB7,
  0x92, 0x18, 0x1C, 0x73, 0xCF, 0x7D, 0xFC, 0xC0, 0x7B, 0x5E, 0xED, 0xEF,
  0xC0, 0x3B, 0x59, 0x8C, 0x69, 0xC0, 0x7B, 0xDA, 0x9D, 0xFF, 0xC0, 0x7B,
  0x18, 0xEC, 0x6B, 0x80, 0x7B, 0x18, 0xEC, 0x63, 0x00, 0x3D, 0x96, 0x36,
  0xDB, 0x67, 0x80, 0x6D, 0xB6, 0x9E, 0xDB, 0x6D, 0x80, 0x72, 0x66, 0x64,
  0xE0, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0xE0, 0x6D, 0xE7, 0x1C, 0xF3, 0x4D,
  0x80, 0x66, 0x64, 0xCD, 0xE0, 0x77, 0x76, 0x7E, 0x7E, 0xFE, 0xF6, 0xF4,
  0x65, 0xD7, 0xDF, 0xDB, 0x6D, 0x80, 0x39, 0xB4, 0xF3, 0xCB, 0x67, 0x00,
  0x7B, 0xDE, 0xFE, 0x63, 0x00, 0x39, 0xB4, 0xF3, 0xCB, 0x67, 0x0C, 0x30,
  0x7B, 0xDE, 0xFF, 0x7B, 0x60, 0x7B, 0x58, 0xE3, 0x5B, 0x80, 0xF6, 0x4C,
  0xCC, 0xC0, 0x6D, 0xB6, 0x96, 0xDB, 0x67, 0x00, 0xDE, 0xBD, 0xEA, 0x73,
  0x00, 0xD7, 0x6E, 0xD7, 0xED, 0xDB, 0x36, 0x00, 0x36, 0x78, 0x60, 0xC3,
  0x8F, 0x3A, 0x00, 0xDF, 0xB9, 0xC4, 0x63, 0x00, 0x78, 0xCC, 0xC6, 0x63,
  0xC0, 0x39, 0x08, 0x46, 0x31, 0x0C, 0xE0, 0xBF, 0x54, 0x31, 0x33, 0x22,
  0x2E, 0xE0, 0x31, 0x9D, 0xA9, 0x80, 0xF0, 0xCC, 0x2B, 0xF7, 0xAF, 0x78,
  0x63, 0x1C, 0xF5, 0xEF, 0x56, 0x37, 0xCC, 0xD6, 0x08, 0x4E, 0xFD, 0xEB,
  0xDE, 0x33, 0xF5, 0xCD, 0x38, 0x19, 0xCE, 0xE2, 0x11, 0x8C, 0x66, 0x00,
  0x2B, 0xF7, 0xAF, 0x78, 0xDC, 0x63, 0x1C, 0xF5, 0xEB, 0x5E, 0x2D, 0xA5,
  0xB6, 0x13, 0x32, 0x26, 0x66, 0x4C, 0x63, 0x1A, 0xB7, 0x7B, 0xDE, 0x6D,
  0xA5, 0xB6, 0x56, 0xFD, 0x7E, 0xBD, 0x7E, 0x80, 0x53, 0xD7, 0xAD, 0x78,
  0x33, 0xF7, 0xAF, 0x30, 0x28, 0xF2, 0xDB, 0x69, 0xE4, 0x30, 0x2B, 0xF7,
  0xAF, 0x78, 0xC6, 0x57, 0x4C, 0xCC, 0x27, 0x66, 0xAE, 0x27, 0xF4, 0x4C,
  0x60, 0x7A, 0xD7, 0xAF, 0x68, 0xBB, 0xAE, 0xCC, 0x5A, 0xBD, 0xFB, 0xE7,
  0xDB, 0x00, 0x2C, 0xE3, 0x8C, 0x7B, 0xE0, 0x2C, 0xB2, 0x8E, 0x30, 0xC2,
  0x38, 0x77, 0x26, 0xCE, 0x32, 0x6E, 0xC4, 0x4E, 0x20, 0xFF, 0xFF, 0xF0,
  0x33, 0x33, 0x32, 0x6E, 0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 8, 1, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 2, 2, 1, -7 },
  { 31, 4, 9, 3, 0, -7 },
  { 36, 4, 9, 3, -1, -7 },
  { 41, 4, 5, 4, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 7, 4, -1, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 3, 6, 3, 0, -6 },
  { 109, 4, 7, 3, -1, -6 },
  { 113, 5, 5, 5, 0, -6 },
  { 117, 5, 3, 5, 0, -5 },
  { 119, 5, 5, 5, 0, -6 },
  { 123, 4, 7, 4, 0, -7 },
  { 127, 7, 8, 7, 0, -7 },
  { 134, 6, 7, 5, -1, -7 },
  { 140, 5, 7, 5, 0, -7 },
  { 145, 5, 7, 5, 0, -7 },
  { 150, 5, 7, 5, 0, -7 },
  { 155, 5, 7, 4, 0, -7 },
  { 160, 5, 7, 4, 0, -7 },
  { 165, 6, 7, 5, 0, -7 },
  { 171, 6, 7, 6, 0, -7 },
  { 177, 4, 7, 4, 0, -7 },
  { 181, 5, 9, 3, -2, -7 },
  { 187, 6, 7, 5, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 8, 7, 7, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 6, 9, 6, 0, -7 },
  { 228, 5, 7, 5, 0, -7 },
  { 233, 5, 7, 4, 0, -7 },
  { 238, 4, 7, 4, 1, -7 },
  { 242, 6, 7, 5, 0, -7 },
  { 248, 5, 7, 5, 1, -7 },
  { 253, 7, 7, 7, 1, -7 },
  { 260, 7, 7, 5, -1, -7 },
  { 267, 5, 7, 5, 1, -7 },
  { 272, 5, 7, 4, 0, -7 },
  { 277, 5, 9, 3, -1, -7 },
  { 283, 2, 7, 4, 1, -7 },
  { 285, 4, 9, 3, -1, -7 },
  { 290, 5, 5, 5, 0, -7 },
  { 294, 4, 1, 4, -1, 1 },
  { 295, 3, 2, 3, 1, -8 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 5, 8, 5, 0, -8 },
  { 305, 4, 6, 4, 0, -6 },
  { 308, 5, 8, 5, 0, -8 },
  { 313, 5, 6, 5, 0, -6 },
  { 317, 5, 10, 3, -1, -8 },
  { 324, 5, 8, 5, 0, -6 },
  { 329, 5, 8, 5, 0, -8 },
  { 334, 3, 8, 3, 0, -8 },
  { 337, 4, 10, 3, -1, -8 },
  { 342, 5, 8, 5, 0, -8 },
  { 347, 3, 8, 3, 0, -8 },
  { 350, 7, 6, 7, 0, -6 },
  { 356, 5, 6, 5, 0, -6 },
  { 360, 5, 6, 5, 0, -6 },
  { 364, 6, 8, 5, -1, -6 },
  { 370, 5, 8, 5, 0, -6 },
  { 375, 4, 6, 4, 0, -6 },
  { 378, 4, 6, 4, 0, -6 },
  { 381, 4, 7, 3, 0, -7 },
  { 385, 5, 6, 5, 0, -6 },
  { 389, 4, 6, 5, 1, -6 },
  { 392, 7, 6, 7, 0, -6 },
  { 398, 6, 6, 5, -1, -6 },
  { 403, 6, 8, 5, -1, -6 },
  { 409, 4, 6, 4, 0, -6 },
  { 412, 4, 9, 3, 0, -7 },
  { 417, 2, 10, 4, 1, -8 },
  { 420, 4, 9, 3, -1, -7 },
  { 425, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC10PT7B_H_
