#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0xE7, 0x31, 0x80, 0x47, 0x30, 0x6E, 0xD9, 0xB7, 0x60,
  0x0B, 0x1B, 0x1A, 0x7F, 0x7F, 0x36, 0xFE, 0xFE, 0x6C, 0x78, 0xD8, 0x08,
  0x7C, 0xFB, 0x47, 0x07, 0x87, 0x4E, 0xFD, 0xF0, 0x81, 0x00, 0x31, 0x8F,
  0x23, 0x6C, 0x6F, 0x0F, 0x69, 0xFB, 0xBB, 0xD8, 0xDA, 0x1B, 0xC6, 0x79,
  0x8E, 0x00, 0x0E, 0x0F, 0x0D, 0x86, 0xC3, 0xC1, 0xDD, 0xFD, 0xDE, 0xEE,
  0x7F, 0x1F, 0xC0, 0x6D, 0xF0, 0x1C, 0xE3, 0x1C, 0x61, 0x86, 0x38, 0xC3,
  0x0C, 0x30, 0xC0, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0x31, 0x9C, 0xCC, 0x00,
  0x28, 0xCF, 0x7F, 0x33, 0xE5, 0xC0, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00,
  0x76, 0x6C, 0xFF, 0x5F, 0x00, 0x03, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7C, 0xDB, 0xB6, 0x6C, 0xDB, 0xB6, 0xEC,
  0xF1, 0xE0, 0x0C, 0x73, 0xFE, 0x58, 0x63, 0x8E, 0x30, 0xC7, 0x00, 0x1C,
  0xFC, 0xF9, 0x70, 0xE3, 0x8E, 0x18, 0x61, 0xFB, 0xF0, 0x1C, 0x7C, 0x98,
  0x33, 0xC7, 0x0F, 0x06, 0x9D, 0xFB, 0xE0, 0x06, 0x1C, 0x78, 0xF3, 0xCD,
  0x93, 0x7F, 0xFC, 0x30, 0x60, 0x1E, 0x7C, 0xF9, 0x87, 0xCF, 0x83, 0x06,
  0x9D, 0xFB, 0xE0, 0x0F, 0x1E, 0x38, 0x70, 0x6C, 0x7E, 0x6E, 0xEE, 0x6C,
  0x7C, 0x78, 0x3F, 0x3F, 0x3E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0xE0, 0x1C, 0x7C, 0xD9, 0xB3, 0xC7, 0x1F, 0x76, 0xED, 0xF9, 0xE0, 0x1C,
  0x7D, 0xDB, 0xB6, 0xEF, 0xDF, 0x86, 0x1D, 0xF3, 0xC0, 0x77, 0x00, 0x04,
  0xEC, 0x39, 0xC0, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x77, 0xB8, 0xF8,
  0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x7F, 0xC8, 0x00,
  0x3D, 0xF6, 0xC3, 0x1C, 0xE7, 0x00, 0x61, 0x8E, 0x00, 0x07, 0x83, 0xF8,
  0xC1, 0x17, 0xB6, 0xF6, 0xB6, 0xB6, 0xD6, 0xD6, 0xDF, 0x98, 0x01, 0x8C,
  0x1F, 0x00, 0x07, 0x0F, 0x0F, 0x1F, 0x1B, 0x3B, 0x3B, 0x3F, 0x7F, 0x67,
  0xE7, 0x3C, 0x3F, 0x37, 0x37, 0x7E, 0x7C, 0x6E, 0x66, 0xEE, 0xFC, 0xF8,
  0x1C, 0x7D, 0xD7, 0x0E, 0x18, 0x30, 0x60, 0xC9, 0xF3, 0xE0, 0x3C, 0x3F,
  0x3F, 0x37, 0x77, 0x77, 0x67, 0x66, 0xEE, 0xFC, 0xF8, 0x3E, 0x7C, 0xC1,
  0x87, 0xCF, 0x9F, 0x30, 0xE1, 0xF3, 0xE0, 0x3E, 0x7C, 0xC1, 0x87, 0x0F,
  0x9F, 0x30, 0xE1, 0xC3, 0x80, 0x1F, 0x3E, 0x72, 0xE0, 0xE0, 0xDE, 0xDE,
  0xCC, 0xCC, 0xFC, 0x7C, 0x39, 0x99, 0xCC, 0xE6, 0x67, 0xF3, 0xF9, 0xFC,
  0xCE, 0xE6, 0x73, 0x3B, 0x80, 0x1F, 0x3E, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x78, 0xFC, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38,
  0x70, 0xE1, 0x8F, 0x1C, 0x00, 0x3B, 0x99, 0x8D, 0xC7, 0xC7, 0xC3, 0xE1,
  0xF0, 0xD8, 0xEC, 0x77, 0x3B, 0x80, 0x39, 0x8C, 0x67, 0x39, 0x8C, 0xE7,
  0xFE, 0x38, 0xF3, 0x8E, 0x39, 0xE3, 0xDE, 0x7F, 0xE6, 0xFE, 0x6F, 0xC6,
  0xEC, 0xEE, 0xCE, 0xDC, 0xCD, 0xC0, 0x39, 0xCE, 0x63, 0x98, 0xF6, 0x7F,
  0x9B, 0xE6, 0xF1, 0xBC, 0xEF, 0x3B, 0xCC, 0x70, 0x1C, 0x3E, 0x77, 0xE7,
  0xE7, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0x78, 0x3C, 0x3E, 0x37, 0x37, 0x76,
  0x7E, 0x7C, 0x60, 0xE0, 0xE0, 0xE0, 0x1C, 0x3E, 0x77, 0xE7, 0xE7, 0xC6,
  0xC6, 0xCE, 0xCC, 0xFC, 0x78, 0x38, 0x38, 0x1C, 0x3C, 0x3E, 0x37, 0x37,
  0x77, 0x7E, 0x7C, 0x6C, 0xEC, 0xEE, 0xEE, 0x1E, 0x7D, 0xDB, 0x87, 0x07,
  0x07, 0x0E, 0x9D, 0xF3, 0xE0, 0x7F, 0xFB, 0xF1, 0x87, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x80, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xEE, 0xCE, 0xCC, 0xDC,
  0xFC, 0xF8, 0xE7, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xE6, 0x7E, 0xE6, 0xEE, 0xEE, 0xEC, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F,
  0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x00, 0x19, 0xC6, 0xE1, 0xB0, 0x7C, 0x1E,
  0x03, 0x01, 0xE0, 0xF8, 0x36, 0x1D, 0x8E, 0x70, 0xE7, 0x6E, 0x6C, 0x7C,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x60, 0x60, 0x1F, 0x9F, 0x81, 0xC0, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0x3F, 0x80, 0x1E, 0x38, 0x61, 0xC3,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0F, 0x1E, 0x00, 0xE6, 0x66, 0x66,
  0x67, 0x33, 0x30, 0x1C, 0xF1, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C,
  0xE3, 0x80, 0x0C, 0x38, 0x71, 0xE3, 0xCC, 0xF1, 0x80, 0xFF, 0xE0, 0xEC,
  0x3F, 0x7E, 0x6E, 0xEE, 0xEC, 0xEC, 0xFC, 0x6C, 0x38, 0x60, 0xC3, 0xF7,
  0xEC, 0xD9, 0xB7, 0xED, 0xFB, 0xE0, 0x3D, 0xF6, 0x38, 0xE3, 0xAF, 0x9E,
  0x03, 0x07, 0x07, 0x3E, 0x7E, 0x6E, 0xEE, 0xEC, 0xEC, 0xFC, 0x6C, 0x3C,
  0xFD, 0xBF, 0xEF, 0x1C, 0x3F, 0x3C, 0x07, 0x0F, 0x0C, 0x1E, 0x1E, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0xF0, 0xF0, 0x40, 0x3F, 0x7E, 0x6E,
  0xEE, 0xEC, 0xEC, 0xFC, 0x6C, 0x1C, 0xB8, 0xF8, 0x60, 0x38, 0x60, 0xC3,
  0xF7, 0xEC, 0xDB, 0xB7, 0xED, 0xDB, 0x70, 0x11, 0xCC, 0x07, 0x39, 0x8C,
  0x67, 0x39, 0x80, 0x04, 0x1C, 0x30, 0x01, 0xC3, 0x86, 0x0C, 0x18, 0x70,
  0xE1, 0x83, 0x1E, 0x38, 0x60, 0x38, 0x30, 0x30, 0x77, 0x7E, 0x7C, 0x78,
  0x7C, 0xFC, 0xEC, 0xCE, 0x39, 0x8C, 0xE7, 0x31, 0x8C, 0xE7, 0x30, 0x7F,
  0xCF, 0xFD, 0x9B, 0xB7, 0x66, 0xED, 0xDB, 0xBB, 0x76, 0xEC, 0x7E, 0xFD,
  0x9B, 0x76, 0xFD, 0xBB, 0x6E, 0x3C, 0xFD, 0x9F, 0x7E, 0xFD, 0xBF, 0x3C,
  0x3F, 0x3F, 0x33, 0x33, 0x37, 0x76, 0x7E, 0x6C, 0x60, 0x60, 0xE0, 0xC0,
  0x3F, 0x7E, 0x6E, 0xEE, 0xEC, 0xEC, 0xFC, 0x6C, 0x1C, 0x18, 0x18, 0x18,
  0x6D, 0xF7, 0x18, 0x63, 0x8E, 0x30, 0x7D, 0xE7, 0x1E, 0x3A, 0x6F, 0xBC,
  0x33, 0x3F, 0xEE, 0x63, 0x18, 0xE7, 0x00, 0x77, 0x76, 0x66, 0x6E, 0x6E,
  0xEC, 0xFC, 0x6C, 0xCF, 0xBB, 0x66, 0xCF, 0x1E, 0x3C, 0x70, 0xDD, 0xF7,
  0x6D, 0xDB, 0xFC, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0x3B, 0x9F, 0x07, 0x83,
  0x83, 0xC1, 0xE1, 0xF9, 0xDC, 0x33, 0x9B, 0x8D, 0x86, 0xC3, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x78, 0x38, 0x18, 0x00, 0x3E, 0x7C, 0x30, 0xC3, 0x8E,
  0x1F, 0x7E, 0x0C, 0x73, 0x8E, 0x31, 0xCE, 0x38, 0x71, 0x86, 0x1C, 0x70,
  0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xE1, 0x86, 0x18, 0x61, 0xCF, 0x30, 0xC7,
  0x3C, 0xE0, 0xE7, 0xFB, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 8, 11, 8, 0, -11 },
  { 23, 7, 12, 7, 0, -11 },
  { 34, 11, 11, 12, 1, -11 },
  { 50, 9, 11, 9, 0, -11 },
  { 63, 3, 4, 4, 1, -11 },
  { 65, 6, 13, 4, 0, -11 },
  { 75, 5, 13, 4, -1, -11 },
  { 84, 6, 7, 7, 1, -12 },
  { 90, 6, 7, 8, 1, -9 },
  { 96, 4, 4, 4, -1, -2 },
  { 98, 4, 2, 5, 0, -5 },
  { 99, 3, 3, 4, 0, -3 },
  { 101, 8, 11, 6, -1, -11 },
  { 112, 7, 11, 7, 0, -11 },
  { 122, 6, 11, 7, 1, -11 },
  { 131, 7, 11, 7, 0, -11 },
  { 141, 7, 11, 7, 0, -11 },
  { 151, 7, 11, 7, 0, -11 },
  { 161, 7, 11, 7, 0, -11 },
  { 171, 8, 11, 7, 0, -11 },
  { 182, 8, 11, 7, 0, -11 },
  { 193, 7, 11, 7, 0, -11 },
  { 203, 7, 11, 7, 0, -11 },
  { 213, 4, 8, 4, 0, -8 },
  { 217, 5, 10, 4, -1, -8 },
  { 224, 6, 7, 8, 1, -9 },
  { 230, 6, 5, 8, 1, -8 },
  { 234, 6, 7, 8, 1, -9 },
  { 240, 6, 11, 6, 0, -11 },
  { 249, 11, 12, 11, 0, -11 },
  { 266, 8, 11, 8, -1, -11 },
  { 277, 8, 11, 8, 0, -11 },
  { 288, 7, 11, 7, 1, -11 },
  { 298, 8, 11, 8, 0, -11 },
  { 309, 7, 11, 6, 0, -11 },
  { 319, 7, 11, 6, 0, -11 },
  { 329, 8, 11, 8, 1, -11 },
  { 340, 9, 11, 8, 0, -11 },
  { 353, 8, 11, 6, -1, -11 },
  { 364, 7, 14, 4, -2, -11 },
  { 377, 9, 11, 8, 0, -11 },
  { 390, 5, 11, 6, 0, -11 },
  { 397, 12, 11, 11, 0, -11 },
  { 414, 10, 11, 9, 0, -11 },
  { 428, 8, 11, 9, 1, -11 },
  { 439, 8, 11, 7, 0, -11 },
  { 450, 8, 14, 9, 1, -11 },
  { 464, 8, 11, 8, 0, -11 },
  { 475, 7, 11, 7, 0, -11 },
  { 485, 7, 11, 6, 1, -11 },
  { 495, 8, 11, 8, 1, -11 },
  { 506, 8, 11, 8, 1, -11 },
  { 517, 12, 11, 11, 1, -11 },
  { 534, 10, 11, 8, -1, -11 },
  { 548, 8, 11, 7, 1, -11 },
  { 559, 9, 11, 7, -1, -11 },
  { 572, 7, 14, 4, -1, -11 },
  { 585, 4, 11, 6, 1, -11 },
  { 591, 6, 14, 4, -1, -11 },
  { 602, 7, 7, 7, 0, -11 },
  { 609, 6, 2, 6, -1, 1 },
  { 611, 3, 2, 5, 2, -11 },
  { 612, 8, 8, 7, 0, -8 },
  { 620, 7, 11, 7, 0, -11 },
  { 630, 6, 8, 6, 0, -8 },
  { 636, 8, 11, 7, 0, -11 },
  { 647, 7, 8, 7, 0, -8 },
  { 654, 8, 15, 5, -2, -11 },
  { 669, 8, 12, 7, 0, -8 },
  { 681, 7, 11, 7, 0, -11 },
  { 691, 5, 12, 4, 0, -12 },
  { 699, 7, 16, 4, -2, -12 },
  { 713, 8, 11, 7, 0, -11 },
  { 724, 5, 11, 4, 0, -11 },
  { 731, 11, 8, 11, 0, -8 },
  { 742, 7, 8, 7, 0, -8 },
  { 749, 7, 8, 7, 0, -8 },
  { 756, 8, 12, 7, -1, -8 },
  { 768, 8, 12, 7, 0, -8 },
  { 780, 6, 8, 5, 0, -8 },
  { 786, 6, 8, 6, 0, -8 },
  { 792, 5, 10, 5, 1, -10 },
  { 799, 8, 8, 7, 0, -8 },
  { 807, 7, 8, 7, 1, -8 },
  { 814, 10, 8, 10, 1, -8 },
  { 824, 9, 8, 7, -1, -8 },
  { 833, 9, 12, 7, -1, -8 },
  { 847, 7, 8, 6, -1, -8 },
  { 854, 6, 13, 5, 0, -11 },
  { 864, 2, 15, 6, 2, -12 },
  { 868, 6, 13, 5, -1, -11 },
  { 878, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC15PT7B_H_
