#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x7F, 0xDF, 0xF7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xE7, 0xF1, 0xFC,
  0xFF, 0x1F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xB9,
  0xE0, 0x7F, 0x60, 0x80, 0xFC, 0xC0, 0x01, 0xFD, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x77, 0xF0, 0x80, 0xEF, 0xC1, 0x81, 0x9F, 0x83, 0xC3,
  0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF8, 0x07,
  0xE0, 0x0F, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0x7E, 0xFC,
  0x0F, 0xC0, 0x1F, 0x8F, 0x83, 0xF0, 0x03, 0xF3, 0xF0, 0x7E, 0x00, 0x7C,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE7, 0xE0, 0x01, 0xF9, 0xF9, 0xFC,
  0x10, 0x3E, 0x3F, 0x3F, 0x1F, 0xC7, 0xEF, 0xCF, 0xC7, 0xFC, 0xFF, 0xF9,
  0xF9, 0xFF, 0xDF, 0xFE, 0x7E, 0x7F, 0xFB, 0xFF, 0xCF, 0xDF, 0xFF, 0xBF,
  0xF3, 0xF3, 0xF3, 0xF3, 0xF8, 0xFE, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x87, 0xC0, 0x07, 0xE3, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF9, 0xF8, 0x03, 0xF0, 0x3F, 0x3F, 0x00,
  0x7E, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x01, 0xFF,
  0xC7, 0xF8, 0x1F, 0xFF, 0x1F, 0xE0, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFB,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0x87, 0xF9, 0xFF, 0xFC,
  0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0x83, 0xFC, 0x3F, 0xFC, 0x0F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xDF,
  0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x02, 0x0F, 0xE0,
  0x1C, 0x7E, 0x00, 0xFB, 0xF0, 0x4F, 0xFF, 0x9E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3E, 0x3F, 0x80, 0xF1, 0xF8, 0x03, 0x07, 0x00, 0x08, 0x20, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x3F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFE, 0x7F, 0xFC, 0x0C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x1F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x7F,
  0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB,
  0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF1, 0xFE, 0x3F, 0x8F,
  0xF1, 0xFC, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xF7, 0xF8, 0x7D, 0xFE, 0x07, 0x3F, 0xC0, 0xC7, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF1, 0xFF, 0x01, 0xE0,
  0xFF, 0x00, 0xC0, 0xFF, 0x00, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xC1, 0xFE, 0x01, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x80, 0x1F, 0xF0, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF7, 0xF8, 0x03, 0xF7,
  0xF8, 0x07, 0xE7, 0xF0, 0x07, 0xCF, 0xF0, 0x0F, 0xCF, 0xF0, 0x1F, 0x8F,
  0xF0, 0x1F, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x61, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC2, 0x00, 0xFF, 0x87, 0x03, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xC6, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87,
  0xF9, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF9,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7C,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0xE3, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0,
  0xFF, 0x08, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x38,
  0x0F, 0x81, 0xF8, 0x7F, 0xF3, 0xE0, 0xFC, 0x3F, 0xFC, 0xFC, 0x3E, 0x1F,
  0xFF, 0x3F, 0x1F, 0x8F, 0xFF, 0xCF, 0xC7, 0xC7, 0xE3, 0xF3, 0xF3, 0xF1,
  0xF0, 0xF8, 0xFC, 0xF8, 0xFC, 0x3E, 0x3E, 0x7E, 0x3E, 0x1F, 0x8F, 0x9F,
  0x1F, 0x87, 0xE3, 0xE7, 0xC7, 0xE1, 0xF0, 0xF9, 0xF1, 0xF0, 0x7C, 0x3E,
  0x7C, 0x7C, 0x3F, 0x1F, 0x3F, 0x3F, 0x0F, 0xC7, 0xCF, 0xCF, 0xC3, 0xE3,
  0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0xF8, 0xFE, 0xFE, 0x7C, 0x3E, 0x1F, 0xFF,
  0xFF, 0x0F, 0x87, 0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0x7F, 0xC0, 0xFC, 0x3F,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0,
  0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFE, 0x07,
  0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x18, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x40, 0xFF, 0x81, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE7, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F,
  0xF8, 0x3F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1C, 0x0F, 0xF8, 0x02, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xFF, 0x3F, 0xE3,
  0xFF, 0xCF, 0xF8, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0xFF, 0x8F, 0xFE, 0x3F,
  0xC4, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x08, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80,
  0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x7F,
  0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F,
  0xFF, 0x3F, 0x7F, 0x81, 0xFE, 0xFD, 0xFF, 0xFC, 0x07, 0xFB, 0xF7, 0xEF,
  0xF0, 0x1F, 0xEF, 0xFF, 0xBF, 0xC0, 0x7F, 0x3F, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0xF3, 0xFC, 0x0F, 0xF3, 0xFF, 0xDF, 0xE0, 0x3F, 0xCF, 0xFE, 0x7F,
  0x80, 0xFE, 0x3F, 0xF9, 0xFE, 0x03, 0xF8, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xE3, 0xFC,
  0x07, 0xF0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xC7,
  0xF8, 0x07, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xE7, 0xF8, 0x0F, 0xEF, 0xE7,
  0xF8, 0x0F, 0xEF, 0xE7, 0xF0, 0x0F, 0xEF, 0xE7, 0xF0, 0x1F, 0xEF, 0xEF,
  0xF0, 0x1F, 0xEF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF,
  0xE0, 0x1F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF,
  0xE0, 0x3F, 0xC7, 0xFF, 0xC0, 0x3F, 0x87, 0xFF, 0xC0, 0x3F, 0x83, 0xFF,
  0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0x83, 0xFF,
  0x80, 0x7F, 0x03, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC,
  0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFF, 0x07, 0xF8,
  0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x78, 0x07, 0xFC,
  0x0C, 0x03, 0xFE, 0x02, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x10, 0x07, 0xFC, 0x0C, 0x07, 0xFC, 0x0F, 0xC7, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F,
  0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x03,
  0xFD, 0xFE, 0x03, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC7, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0x87,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xE3, 0xFC,
  0x1F, 0xE3, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0xF9, 0xFE, 0x07, 0xF9, 0xFF, 0xEF, 0xF8, 0x1F, 0xEF, 0xFF, 0x3F, 0xC0,
  0x7F, 0xBF, 0xFC, 0xFF, 0x01, 0xFD, 0xFF, 0xF7, 0xF8, 0x07, 0xF7, 0xFF,
  0xDF, 0xE0, 0x1F, 0xDF, 0xBF, 0x7F, 0x80, 0x7F, 0xFE, 0xFF, 0xFC, 0x01,
  0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0,
  0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF,
  0xE0, 0xFF, 0x7F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x00, 0x20, 0x00, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFE,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xE7,
  0xFC, 0x3F, 0xC7, 0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x20, 0x03, 0xFD, 0xFC, 0x03, 0xFB,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0x7F,
  0xC0, 0xFE, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x18,
  0x3F, 0xE0, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x10, 0xFF, 0x06, 0x0F, 0xF9, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x3F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF1, 0xFF,
  0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F,
  0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x08, 0x7F, 0x80,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x23, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xFE, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x02, 0x00, 0x7F, 0x80, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x60, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x23, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x00,
  0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFE, 0x01, 0xFC,
  0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x3F, 0x1F, 0xC1, 0xFC, 0x03, 0xF3, 0xFE, 0x7F, 0xE0, 0x3F,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x9F, 0xF0, 0xFF, 0x8F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8,
  0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x03, 0xF1, 0xFC, 0x03, 0xF3, 0xFE,
  0x03, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0,
  0xFF, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF9,
  0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF,
  0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF,
  0x07, 0xFB, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xF8, 0x03, 0xF7, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFC, 0xFF,
  0x03, 0xFE, 0xFE, 0x07, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0xC7, 0xFC, 0x3F, 0xC7, 0xFC,
  0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x8F, 0xC0,
  0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFE, 0x18, 0x1F, 0xE0, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x80, 0xFF,
  0x8F, 0x9F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xB0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xEF, 0xE0, 0x7F, 0xCF, 0xC0, 0x3F, 0x8F, 0xC0, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0x0F, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x87, 0xFC, 0x3F, 0xDF, 0xE3, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0xC7,
  0xF9, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0x9F, 0xFC, 0xFF, 0x1F, 0xC7, 0xFF,
  0x3F, 0xC7, 0xF3, 0xFF, 0x8F, 0xE1, 0xFC, 0xFF, 0xE7, 0xF8, 0x7F, 0x3F,
  0xF9, 0xFC, 0x1F, 0xDF, 0xFE, 0x7F, 0x07, 0xF7, 0xFF, 0xBF, 0xC1, 0xFD,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFD, 0xFB, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x07,
  0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0,
  0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F,
  0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC,
  0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x2E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x05, 0xFF, 0x80, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x80, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 15, 36, 13, 0, -35 },
  { 69, 20, 13, 22, 5, -35 },
  { 102, 27, 35, 26, 0, -35 },
  { 221, 23, 40, 23, 1, -37 },
  { 336, 35, 35, 39, 3, -35 },
  { 490, 30, 35, 29, 0, -35 },
  { 622, 10, 13, 12, 5, -35 },
  { 639, 17, 44, 14, 1, -36 },
  { 733, 17, 44, 14, -4, -36 },
  { 827, 21, 23, 22, 3, -38 },
  { 888, 21, 24, 25, 2, -29 },
  { 951, 12, 14, 13, -3, -7 },
  { 972, 15, 8, 15, 0, -17 },
  { 987, 9, 10, 13, 0, -9 },
  { 999, 27, 35, 19, -3, -35 },
  { 1118, 21, 35, 23, 2, -35 },
  { 1210, 19, 35, 23, 4, -35 },
  { 1294, 24, 35, 23, -1, -35 },
  { 1399, 24, 35, 23, 0, -35 },
  { 1504, 24, 35, 23, 0, -35 },
  { 1609, 23, 35, 23, 1, -35 },
  { 1710, 23, 35, 23, 2, -35 },
  { 1811, 25, 35, 23, 1, -35 },
  { 1921, 24, 35, 23, 0, -35 },
  { 2026, 22, 35, 23, 1, -35 },
  { 2123, 13, 28, 13, 0, -27 },
  { 2169, 16, 34, 13, -3, -27 },
  { 2237, 21, 25, 25, 2, -30 },
  { 2303, 21, 17, 25, 2, -26 },
  { 2348, 22, 25, 25, 2, -30 },
  { 2417, 20, 36, 18, 1, -35 },
  { 2507, 34, 39, 35, 1, -35 },
  { 2673, 26, 35, 26, -3, -35 },
  { 2787, 26, 35, 25, 0, -35 },
  { 2901, 24, 35, 23, 2, -35 },
  { 3006, 27, 35, 27, 0, -35 },
  { 3125, 23, 35, 21, 0, -35 },
  { 3226, 23, 35, 20, 0, -35 },
  { 3327, 26, 35, 27, 2, -35 },
  { 3441, 30, 35, 28, 0, -35 },
  { 3573, 24, 35, 18, -2, -35 },
  { 3678, 23, 46, 13, -8, -35 },
  { 3811, 30, 35, 25, 0, -35 },
  { 3943, 18, 35, 20, 0, -35 },
  { 4022, 38, 35, 36, 0, -35 },
  { 4189, 32, 35, 30, 0, -35 },
  { 4329, 26, 36, 28, 2, -36 },
  { 4446, 25, 35, 24, 0, -35 },
  { 4556, 26, 44, 28, 2, -36 },
  { 4699, 25, 35, 25, 0, -35 },
  { 4809, 25, 35, 21, -1, -35 },
  { 4919, 21, 35, 21, 4, -35 },
  { 5011, 27, 35, 27, 2, -35 },
  { 5130, 25, 35, 25, 5, -35 },
  { 5240, 38, 35, 36, 3, -35 },
  { 5407, 31, 35, 25, -3, -35 },
  { 5543, 23, 35, 24, 5, -35 },
  { 5644, 27, 35, 21, -2, -35 },
  { 5763, 20, 44, 14, -2, -36 },
  { 5873, 11, 35, 19, 5, -35 },
  { 5922, 21, 44, 14, -4, -36 },
  { 6038, 24, 23, 23, -1, -35 },
  { 6107, 20, 6, 19, -5, 3 },
  { 6122, 11, 8, 16, 7, -38 },
  { 6133, 24, 28, 24, 1, -28 },
  { 6217, 24, 37, 24, -1, -37 },
  { 6328, 20, 28, 20, 1, -28 },
  { 6398, 26, 37, 24, 1, -37 },
  { 6519, 21, 28, 23, 1, -28 },
  { 6593, 26, 49, 15, -5, -37 },
  { 6753, 26, 40, 24, -1, -28 },
  { 6883, 24, 37, 24, -1, -37 },
  { 6994, 16, 38, 12, -1, -38 },
  { 7070, 21, 50, 12, -6, -38 },
  { 7202, 27, 37, 24, -1, -37 },
  { 7327, 16, 37, 12, -1, -37 },
  { 7401, 36, 28, 36, -1, -28 },
  { 7527, 24, 28, 24, -1, -28 },
  { 7611, 22, 28, 23, 1, -28 },
  { 7688, 26, 40, 24, -3, -28 },
  { 7818, 24, 40, 24, 1, -28 },
  { 7938, 21, 28, 17, -1, -28 },
  { 8012, 20, 28, 19, 0, -28 },
  { 8082, 16, 33, 17, 2, -33 },
  { 8148, 24, 27, 24, 1, -27 },
  { 8229, 22, 27, 22, 3, -27 },
  { 8304, 34, 27, 33, 2, -27 },
  { 8419, 28, 27, 23, -3, -27 },
  { 8514, 28, 39, 22, -3, -27 },
  { 8651, 23, 27, 19, -2, -27 },
  { 8729, 21, 43, 17, 0, -35 },
  { 8842, 7, 49, 19, 6, -38 },
  { 8885, 20, 43, 17, -3, -35 },
  { 8993, 22, 9, 25, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC49PT7B_H_
