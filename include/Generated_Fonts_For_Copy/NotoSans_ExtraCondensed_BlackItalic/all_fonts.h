#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_BlackItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_BlackItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_BlackItalic72pt7b.h"
