#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x00, 0x40, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3,
  0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x80, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFB,
  0xE0, 0x3F, 0xB0, 0xC0, 0x7E, 0x60, 0x80, 0xFD, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x40, 0x6F, 0xE0, 0xC0, 0xDF, 0xC1, 0xE3,
  0xBF, 0x83, 0xF7, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF,
  0x81, 0xF8, 0x07, 0xE7, 0xE0, 0xFC, 0x01, 0xF9, 0xF8, 0x3F, 0x00, 0x7C,
  0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE3, 0xF0, 0x03,
  0xF1, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x3F, 0x00,
  0x0F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE7, 0xE7, 0xE3, 0xFC, 0xFF, 0xF9, 0xF9,
  0xFF, 0xBF, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0x7E, 0x7F, 0xFD, 0xFF, 0x9F,
  0x9F, 0xBF, 0x3F, 0xCF, 0xCF, 0xCF, 0xC3, 0x83, 0xF3, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x8F, 0xC0,
  0x1F, 0x87, 0xE3, 0xE0, 0x07, 0xE1, 0xF9, 0xF8, 0x03, 0xF0, 0x7C, 0x7E,
  0x00, 0xFC, 0x1F, 0x1F, 0x80, 0x7E, 0x07, 0xEF, 0xC0, 0x1F, 0x81, 0xFF,
  0xF0, 0x0F, 0xC0, 0x7F, 0xF8, 0x03, 0xF0, 0x1F, 0xFC, 0x01, 0xF8, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xF8, 0x1F, 0xFC, 0x7F, 0x83,
  0xFF, 0xF3, 0xFC, 0x3F, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF,
  0x87, 0xF8, 0x7F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0xFC, 0x03, 0xFE, 0x3F,
  0xF0, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE3, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x30, 0xFC, 0x03, 0x8F, 0xC0, 0x3E,
  0xFC, 0x77, 0xFF, 0xBF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xBF, 0x03, 0xFB, 0xF8, 0x1F, 0x1F, 0xC0, 0xF1, 0xF8, 0x06, 0x1E,
  0x00, 0x20, 0xC0, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFE, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F,
  0x8F, 0xF3, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFE,
  0x7F, 0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0,
  0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xC7,
  0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xEF, 0xF0, 0x79, 0xFE, 0x06,
  0x3F, 0xC0, 0x8F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF9, 0xFF, 0x01,
  0xE1, 0xFF, 0x01, 0xC1, 0xFE, 0x00, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF1, 0xFF, 0x01, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE2, 0x00,
  0x7F, 0xC6, 0x01, 0xFF, 0x8F, 0xDF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0x7F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xFC, 0x03, 0xE7, 0xF8, 0x0F,
  0xCF, 0xF0, 0x3F, 0x1F, 0xE0, 0x7C, 0x3F, 0x81, 0xF8, 0xFF, 0x07, 0xE1,
  0xFE, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE2,
  0x00, 0xFF, 0x8C, 0x07, 0xFC, 0x3F, 0x7F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x02, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xCF,
  0x00, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC,
  0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F,
  0x8F, 0xE3, 0xFE, 0x3F, 0x8F, 0xF0, 0xFF, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFD, 0xFE, 0x0F,
  0xF3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC,
  0x1F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFE, 0xFF, 0x00, 0x47, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xC3, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x20, 0x00,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x78, 0xFF, 0x0C, 0x0F, 0xE2, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x7F, 0x8F, 0xC3, 0xF0, 0xFF, 0xF3, 0xE1, 0xF0,
  0xFF, 0xF9, 0xF1, 0xF8, 0xFF, 0xF8, 0xF8, 0xF8, 0xFE, 0xFC, 0x7C, 0xFC,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3F, 0x1F, 0x3E, 0x3E, 0x1F, 0x0F, 0xBE,
  0x3F, 0x0F, 0x8F, 0x9F, 0x1F, 0x0F, 0xC7, 0xCF, 0x8F, 0x87, 0xE3, 0xE7,
  0xCF, 0xC3, 0xE1, 0xF7, 0xE7, 0xE1, 0xF1, 0xF3, 0xE3, 0xF1, 0xF8, 0xF9,
  0xF1, 0xF8, 0xFC, 0xF8, 0xF8, 0xFC, 0xFE, 0x7C, 0x7C, 0x7F, 0xFF, 0xFC,
  0x3E, 0x1F, 0xFF, 0xFE, 0x1F, 0x0F, 0xF3, 0xFE, 0x0F, 0x83, 0xF1, 0xFC,
  0x07, 0xE0, 0x20, 0x18, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x06, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0x81,
  0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xFD, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x81,
  0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFC,
  0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0x78, 0x0F, 0xF8, 0x10, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE,
  0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x78, 0x0F, 0xF8, 0x06, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F, 0xFE, 0x3F, 0xE3, 0xFF, 0x8F, 0xF8,
  0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0xFF, 0x1F, 0xFE, 0x3F, 0xC7, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x04, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0B, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF,
  0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF,
  0xF3, 0xF7, 0xF0, 0x1F, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7E, 0xFF,
  0x01, 0xFF, 0xFF, 0xFB, 0xFC, 0x07, 0xF7, 0xFF, 0xEF, 0xE0, 0x1F, 0xDF,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xFD, 0xFE, 0x03, 0xFD, 0xFF, 0xE7, 0xF8,
  0x0F, 0xF7, 0xFF, 0x9F, 0xC0, 0x3F, 0x9F, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0x8F, 0xF0, 0x1F, 0xE7, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE1, 0xFE, 0x03,
  0xF8, 0x3F, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xC0, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xC1, 0xFC,
  0x07, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x1F, 0xE0,
  0x3F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xFB, 0xFC, 0x07, 0xF7, 0xF7, 0xF8, 0x1F, 0xEF, 0xEF, 0xE0, 0x3F,
  0xDF, 0xDF, 0xC0, 0x7F, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0xFF, 0x01, 0xFC,
  0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xF0, 0x1F, 0xE3,
  0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF, 0x81, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF,
  0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF,
  0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xEF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFE,
  0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFB,
  0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC,
  0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF8, 0x3F, 0xCF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xFC, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x1C, 0x03, 0xFC, 0x04,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x10,
  0x07, 0xF8, 0x0C, 0x07, 0xFC, 0x0F, 0x87, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0x83, 0xFC, 0x1F,
  0xC3, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0xFF, 0x01,
  0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xE0, 0x7F,
  0xDF, 0xE0, 0x7F, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x8F, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xE3,
  0xFC, 0x1F, 0xE3, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x07, 0xF9,
  0xFF, 0xCF, 0xF0, 0x3F, 0x9F, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0xF3, 0xFC,
  0x0F, 0xE7, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0xFD, 0xFE, 0x03, 0xFB, 0xF7,
  0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF,
  0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x7F, 0x83, 0xFE, 0x7F,
  0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F,
  0x8F, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC,
  0x0F, 0xF1, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xBF, 0xE7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x00, 0xF0,
  0xFE, 0x07, 0xF9, 0xFC, 0x1F, 0xF3, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F,
  0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0xFF, 0x3F,
  0x80, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0xF8, 0x03, 0xFB,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7E, 0x7F,
  0xC0, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x08,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x60, 0xFF, 0x9E, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7,
  0xF0, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7,
  0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xE7, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0x0F, 0xF0, 0x18,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x4F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xEF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFB, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x02,
  0x00, 0x7F, 0x81, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0xF8, 0x03, 0xFB,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x04, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x7E, 0x7F,
  0x8F, 0xF8, 0x0F, 0xDF, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xCF, 0xFC, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87,
  0xF0, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x03, 0xF3, 0xFC, 0x03, 0xF7,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7,
  0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F,
  0xBF, 0xC3, 0xF9, 0xFE, 0x3F, 0xCF, 0xF3, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xF8, 0x07, 0xF7,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xDF, 0xF8, 0x07, 0xF7, 0xFC,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x07, 0xF9,
  0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF0, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x40, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF9,
  0xE0, 0xFF, 0x04, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x40, 0x7F, 0x8F, 0x1F, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xEF, 0xC0, 0xFF, 0x9F, 0x80, 0xFE, 0x7F, 0x00, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3,
  0xFC, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x01, 0xFF,
  0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x7F, 0xBF, 0xC7, 0xFC, 0x3F, 0xDF, 0xC3,
  0xFE, 0x1F, 0xCF, 0xE3, 0xFF, 0x1F, 0xE7, 0xF1, 0xFF, 0x8F, 0xF3, 0xF8,
  0xFF, 0xC7, 0xF1, 0xFC, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0xF3, 0xF8, 0x7F,
  0x3F, 0xF9, 0xFC, 0x3F, 0xBF, 0xFD, 0xFE, 0x1F, 0xDF, 0xFE, 0xFE, 0x0F,
  0xEF, 0xBF, 0x7F, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xEF, 0xBF, 0x81,
  0xFF, 0xEF, 0xDF, 0xC0, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xE0,
  0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x06, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x09, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x1F, 0xF4, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 15, 35, 12, 0, -34 },
  { 67, 20, 12, 22, 4, -34 },
  { 97, 27, 34, 25, 0, -34 },
  { 212, 23, 39, 23, 1, -36 },
  { 325, 34, 35, 38, 3, -35 },
  { 474, 29, 35, 29, 0, -35 },
  { 601, 10, 12, 12, 4, -34 },
  { 616, 17, 43, 14, 1, -35 },
  { 708, 17, 43, 14, -4, -35 },
  { 800, 20, 23, 21, 3, -37 },
  { 858, 21, 24, 24, 2, -29 },
  { 921, 12, 14, 12, -3, -7 },
  { 942, 14, 8, 15, 0, -17 },
  { 956, 9, 9, 12, 0, -8 },
  { 967, 27, 35, 19, -3, -35 },
  { 1086, 21, 35, 23, 2, -35 },
  { 1178, 19, 34, 23, 4, -34 },
  { 1259, 24, 35, 23, -1, -35 },
  { 1364, 23, 35, 23, 0, -35 },
  { 1465, 23, 34, 23, 0, -34 },
  { 1563, 22, 34, 23, 1, -34 },
  { 1657, 22, 35, 23, 2, -35 },
  { 1754, 24, 34, 23, 1, -34 },
  { 1856, 23, 35, 23, 0, -35 },
  { 1957, 22, 35, 23, 1, -35 },
  { 2054, 13, 28, 13, 0, -27 },
  { 2100, 16, 34, 13, -3, -27 },
  { 2168, 21, 24, 24, 2, -29 },
  { 2231, 21, 17, 24, 2, -25 },
  { 2276, 21, 24, 24, 2, -29 },
  { 2339, 19, 36, 18, 1, -35 },
  { 2425, 33, 39, 34, 1, -35 },
  { 2586, 26, 34, 26, -3, -34 },
  { 2697, 25, 34, 25, 0, -34 },
  { 2804, 24, 35, 23, 2, -35 },
  { 2909, 26, 34, 26, 0, -34 },
  { 3020, 23, 34, 20, 0, -34 },
  { 3118, 23, 34, 20, 0, -34 },
  { 3216, 26, 35, 26, 2, -35 },
  { 3330, 29, 34, 27, 0, -34 },
  { 3454, 24, 34, 18, -2, -34 },
  { 3556, 23, 45, 13, -8, -34 },
  { 3686, 30, 34, 25, 0, -34 },
  { 3814, 17, 34, 19, 0, -34 },
  { 3887, 38, 34, 36, 0, -34 },
  { 4049, 31, 34, 29, 0, -34 },
  { 4181, 26, 35, 28, 2, -35 },
  { 4295, 25, 34, 23, 0, -34 },
  { 4402, 26, 43, 28, 2, -35 },
  { 4542, 25, 34, 24, 0, -34 },
  { 4649, 25, 35, 21, -1, -35 },
  { 4759, 21, 34, 21, 3, -34 },
  { 4849, 26, 34, 26, 2, -34 },
  { 4960, 25, 34, 25, 4, -34 },
  { 5067, 37, 34, 36, 3, -34 },
  { 5225, 31, 34, 24, -3, -34 },
  { 5357, 24, 34, 23, 4, -34 },
  { 5459, 26, 34, 21, -2, -34 },
  { 5570, 20, 43, 14, -2, -35 },
  { 5678, 11, 35, 19, 5, -35 },
  { 5727, 20, 43, 14, -4, -35 },
  { 5835, 24, 22, 22, -1, -34 },
  { 5901, 20, 6, 18, -5, 3 },
  { 5916, 10, 8, 16, 7, -37 },
  { 5926, 23, 27, 23, 1, -27 },
  { 6004, 24, 36, 23, -1, -36 },
  { 6112, 20, 27, 19, 1, -27 },
  { 6180, 25, 36, 23, 1, -36 },
  { 6293, 21, 27, 22, 1, -27 },
  { 6364, 25, 49, 15, -5, -37 },
  { 6518, 25, 39, 23, -1, -27 },
  { 6640, 24, 36, 24, -1, -36 },
  { 6748, 16, 37, 12, -1, -37 },
  { 6822, 21, 49, 12, -6, -37 },
  { 6951, 27, 36, 23, -1, -36 },
  { 7073, 16, 36, 12, -1, -36 },
  { 7145, 35, 27, 35, -1, -27 },
  { 7264, 24, 27, 24, -1, -27 },
  { 7345, 21, 27, 23, 1, -27 },
  { 7416, 26, 39, 23, -3, -27 },
  { 7543, 23, 39, 23, 1, -27 },
  { 7656, 20, 27, 17, -1, -27 },
  { 7724, 19, 27, 19, 0, -27 },
  { 7789, 16, 32, 16, 2, -32 },
  { 7853, 23, 27, 24, 1, -27 },
  { 7931, 22, 27, 22, 3, -27 },
  { 8006, 33, 27, 33, 2, -27 },
  { 8118, 27, 27, 22, -3, -27 },
  { 8210, 28, 39, 22, -3, -27 },
  { 8347, 22, 27, 19, -2, -27 },
  { 8422, 20, 42, 17, 0, -34 },
  { 8527, 7, 48, 19, 6, -37 },
  { 8569, 19, 42, 17, -3, -34 },
  { 8669, 21, 10, 24, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC48PT7B_H_
