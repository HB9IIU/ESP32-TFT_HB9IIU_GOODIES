#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x80,
  0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0x06, 0xC1, 0xD8, 0x37, 0x06, 0xC3, 0xFE,
  0xFF, 0x86, 0xC1, 0xD8, 0xFF, 0x9F, 0xF1, 0xD8, 0x33, 0x06, 0xE1, 0xD8,
  0x00, 0x02, 0x07, 0xC7, 0xE7, 0xE3, 0x41, 0xE0, 0xF8, 0x3E, 0x0F, 0x47,
  0x9B, 0xDF, 0xCF, 0xC0, 0x80, 0x40, 0x18, 0x71, 0xF1, 0x86, 0xCE, 0x3B,
  0x30, 0xCD, 0xC3, 0x76, 0x0D, 0xB7, 0xBF, 0xDF, 0x76, 0xDC, 0x3B, 0x70,
  0xCD, 0x87, 0x36, 0x18, 0xF8, 0xC3, 0xC0, 0x07, 0x01, 0xF0, 0x7E, 0x0C,
  0xC1, 0xF8, 0x3E, 0x07, 0xB9, 0xF7, 0x7F, 0xFD, 0xFB, 0x9E, 0x7F, 0xCF,
  0xFC, 0xFF, 0x80, 0xFE, 0xEE, 0xE0, 0x0E, 0x38, 0x71, 0xC3, 0x86, 0x1C,
  0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0xE0,
  0x10, 0x1C, 0x5C, 0x7F, 0xFF, 0x3C, 0x7C, 0x7E, 0x24, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x3B, 0x9C, 0xCE, 0x60, 0x7D, 0xEF,
  0x80, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x0C, 0x3F, 0x3F,
  0x77, 0x77, 0xE7, 0xE7, 0xE7, 0xEE, 0xEE, 0xEE, 0xFC, 0xFC, 0x78, 0x0E,
  0x3C, 0xFB, 0xEF, 0xDB, 0x97, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x00,
  0x07, 0x03, 0xE1, 0xFC, 0x67, 0x11, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xFC, 0x7F, 0x3F, 0xC0, 0x0E, 0x1F, 0xCF, 0xE2, 0x70, 0x38,
  0x38, 0x78, 0x7C, 0x0F, 0x03, 0xA3, 0xDF, 0xEF, 0xE7, 0xE0, 0x03, 0x81,
  0xC1, 0xE1, 0xF1, 0xF0, 0xF8, 0xDC, 0xEE, 0x6F, 0x7F, 0xFF, 0xC1, 0xC0,
  0xE0, 0xE0, 0x1F, 0x8F, 0xC7, 0xE7, 0x03, 0x81, 0xF0, 0xFC, 0xFE, 0x07,
  0x03, 0xA3, 0xDF, 0xEF, 0xE7, 0xE0, 0x07, 0x8F, 0x8F, 0xCF, 0x07, 0x07,
  0x73, 0xF9, 0xFC, 0xEF, 0x77, 0x3B, 0x9F, 0xCF, 0xC3, 0xC0, 0x3F, 0xBF,
  0xDF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x00, 0x07, 0x0F, 0xCF, 0xE7, 0x73, 0xB9, 0xF8, 0x78, 0x7C, 0x77,
  0x7B, 0xB9, 0xDD, 0xEF, 0xE3, 0xE0, 0x0E, 0x0F, 0x8F, 0xE7, 0x77, 0xBB,
  0x9D, 0xDE, 0xFF, 0x3F, 0x03, 0x83, 0xDF, 0xCF, 0xC7, 0xC0, 0x11, 0xCE,
  0x60, 0x00, 0x00, 0xF7, 0x38, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x39,
  0xC7, 0x18, 0xE3, 0x00, 0x01, 0x03, 0x0F, 0x3E, 0xF8, 0xF0, 0x7E, 0x1F,
  0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xF0,
  0x7C, 0x1F, 0x0F, 0x7E, 0xF8, 0xE0, 0x80, 0x1C, 0xFD, 0xFA, 0x70, 0xE3,
  0x8E, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x3F, 0x87,
  0x8E, 0x30, 0x33, 0x3F, 0xBB, 0x6D, 0xB3, 0x6D, 0x9B, 0x6D, 0xDE, 0x6D,
  0xB3, 0xFD, 0xDD, 0xC6, 0x00, 0x3C, 0xE0, 0xFF, 0x00, 0x03, 0xC1, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC3, 0x71, 0xDC, 0x77, 0x39, 0xCF, 0xF7, 0xFD, 0xC7,
  0x71, 0xFC, 0x70, 0x1E, 0x07, 0xE3, 0xFC, 0xE7, 0x39, 0xCE, 0xE7, 0xF1,
  0xFC, 0x73, 0x9C, 0xE7, 0x7B, 0xFE, 0xFF, 0x3F, 0x80, 0x0F, 0x0F, 0xCF,
  0xCF, 0x27, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0x8F, 0xC3,
  0xE0, 0x1E, 0x07, 0xE3, 0xFC, 0xEF, 0x39, 0xCE, 0x77, 0x9D, 0xC7, 0x73,
  0xDC, 0xE7, 0x7B, 0xFC, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0x03,
  0x81, 0xC9, 0xF8, 0xFC, 0x70, 0x38, 0x1C, 0x1F, 0xCF, 0xC7, 0xE0, 0x1F,
  0x8F, 0xCF, 0xC7, 0x03, 0x81, 0xC1, 0xF8, 0xFC, 0x7E, 0x38, 0x1C, 0x1E,
  0x0E, 0x07, 0x00, 0x07, 0x87, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0E, 0x7B,
  0xBE, 0xEF, 0xB9, 0xCE, 0x73, 0xFC, 0xFF, 0x1F, 0x80, 0x1C, 0xE3, 0x9C,
  0xF3, 0x9C, 0x73, 0x9E, 0x73, 0x9F, 0xF3, 0xFE, 0x71, 0xCE, 0x79, 0xCE,
  0x79, 0xCE, 0x39, 0xCF, 0x00, 0x1F, 0xC7, 0xE0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7E, 0x3F, 0x80, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xC0, 0xE0, 0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0xF1, 0xDE, 0x3D,
  0xC3, 0xBC, 0x3B, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77,
  0x0F, 0x70, 0xE7, 0x0E, 0x78, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x1E, 0x38,
  0x70, 0xE1, 0xC7, 0xFF, 0xFF, 0x80, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1,
  0xF3, 0xE3, 0xE7, 0xC7, 0xDF, 0x9F, 0xB7, 0x3F, 0xFC, 0x7F, 0xF8, 0xEF,
  0x71, 0xDE, 0xE7, 0x3B, 0xCE, 0x77, 0x1C, 0xCE, 0x00, 0x1C, 0x71, 0xC7,
  0x3E, 0x73, 0xE7, 0x3E, 0xE3, 0xEE, 0x76, 0xE7, 0x7E, 0x77, 0xE7, 0x7C,
  0x77, 0xCE, 0x7C, 0xE3, 0xCE, 0x3C, 0x0F, 0x07, 0xE3, 0xFD, 0xEF, 0x71,
  0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x7B, 0xFC, 0xFE, 0x1F, 0x00,
  0x1E, 0x07, 0xE3, 0xFC, 0xEF, 0x3B, 0xCE, 0xF7, 0xB9, 0xFE, 0x7F, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x0F, 0x07, 0xE3, 0xFD, 0xEF, 0x71,
  0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x7B, 0xFC, 0xFE, 0x1F, 0x01,
  0xC0, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0xE3, 0xFC, 0xEF, 0x3B, 0xCE, 0xF7,
  0xF9, 0xFC, 0x7E, 0x1F, 0xC7, 0x73, 0xDC, 0xE7, 0x39, 0xE0, 0x0F, 0x0F,
  0xCF, 0xE7, 0x27, 0x81, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xA3, 0xDF, 0xCF,
  0xE7, 0xE0, 0x7F, 0xBF, 0x9F, 0xD3, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x80, 0x39, 0xCE, 0x77, 0x1D, 0xCF, 0x73,
  0x9C, 0xEF, 0x3B, 0x9E, 0xE7, 0x39, 0xCE, 0x73, 0xFC, 0xFE, 0x1F, 0x00,
  0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xE7, 0x3B, 0x8E, 0xE3, 0xF8, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x71, 0x8E, 0xE7, 0x3D, 0xCE, 0x73,
  0xBC, 0xE7, 0x7B, 0x8F, 0xF7, 0x1B, 0xFE, 0x77, 0xF8, 0xFF, 0xF1, 0xFF,
  0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0x3C, 0x1E, 0x78, 0x00, 0x1C, 0xF1, 0xCE,
  0x1F, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x87, 0xB8, 0x73, 0x8F, 0x38, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE3,
  0xE1, 0xF0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x1F, 0xE3,
  0xF8, 0x7F, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80,
  0xE0, 0x3F, 0x87, 0xF1, 0xFE, 0x00, 0x0F, 0x1F, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xF8, 0xF8, 0xEE,
  0xEE, 0xE6, 0x66, 0x77, 0x77, 0x73, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x78, 0xF0, 0x06, 0x03, 0x03,
  0x83, 0xE1, 0xF1, 0xF9, 0xCC, 0xE7, 0xE3, 0x80, 0x7F, 0xFF, 0xFE, 0xEE,
  0x70, 0x19, 0xCF, 0xE3, 0xF9, 0xCE, 0x73, 0x9D, 0xCE, 0x73, 0x9C, 0xFF,
  0x3F, 0xC7, 0x60, 0x1C, 0x1C, 0x0E, 0x07, 0x63, 0xF9, 0xFD, 0xEE, 0xE7,
  0x73, 0xBB, 0xFD, 0xDE, 0xEF, 0xE6, 0xE0, 0x0E, 0x3F, 0x3E, 0x72, 0x70,
  0x70, 0xF0, 0xE0, 0xF4, 0x7C, 0x7C, 0x01, 0xC0, 0x70, 0x1C, 0x6F, 0x3F,
  0x8F, 0xE7, 0x39, 0xCE, 0x77, 0x39, 0xCE, 0x73, 0xFC, 0xFF, 0x1D, 0x80,
  0x0E, 0x0F, 0x8F, 0xEE, 0x77, 0x73, 0xFB, 0xF1, 0xC0, 0xF2, 0x3F, 0x0F,
  0x80, 0x01, 0x01, 0xF0, 0x78, 0x1C, 0x0F, 0x87, 0xE1, 0xF0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3C, 0x0F,
  0x03, 0x00, 0x06, 0xE3, 0xD8, 0x7F, 0x1C, 0xE3, 0x9C, 0x77, 0x1C, 0xE3,
  0x9C, 0x7F, 0x8F, 0xF0, 0xFC, 0x03, 0x88, 0x71, 0xFC, 0x3F, 0x81, 0x80,
  0x1C, 0x1C, 0x0E, 0x07, 0x63, 0xF9, 0xFD, 0xEE, 0xE7, 0x73, 0xBB, 0xBD,
  0xDC, 0xEE, 0x77, 0x70, 0x18, 0x73, 0x80, 0x38, 0xE3, 0x9C, 0x71, 0xC7,
  0x1C, 0xE3, 0x8E, 0x00, 0x06, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xF0, 0xC0,
  0x1C, 0x0E, 0x03, 0x80, 0xE7, 0x3B, 0x8F, 0xE7, 0x71, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE3, 0xBC, 0xE7, 0x39, 0xC0, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C,
  0x71, 0xCF, 0x38, 0xE3, 0x80, 0x33, 0x31, 0xBF, 0xCF, 0xFE, 0xF7, 0x77,
  0x3B, 0xBB, 0x9D, 0xDC, 0xFE, 0xE7, 0xE7, 0x77, 0x3B, 0xBB, 0x9C, 0x33,
  0x1B, 0xCF, 0xEF, 0x77, 0x3B, 0x9D, 0xDD, 0xEE, 0xE7, 0x73, 0xBB, 0x80,
  0x0E, 0x0F, 0x8F, 0xEE, 0x77, 0x3B, 0x9F, 0x9D, 0xCE, 0xFF, 0x3F, 0x0F,
  0x00, 0x19, 0x86, 0xF1, 0xFC, 0xF7, 0x39, 0xCE, 0x73, 0xBC, 0xEE, 0x7F,
  0x9F, 0xC7, 0xF1, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0D, 0xCF, 0x63,
  0xF9, 0xCE, 0x73, 0x9D, 0xCE, 0x73, 0x9C, 0xFF, 0x3F, 0xC7, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x33, 0x36, 0x3E, 0x7E, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0x1C, 0x3F, 0x7E, 0x72, 0x78, 0x7C, 0x3C, 0x1E,
  0xDC, 0xFC, 0xF8, 0x18, 0xE3, 0xFF, 0xFD, 0xCF, 0x38, 0xE3, 0x8E, 0xBC,
  0xF0, 0x39, 0xCE, 0xE3, 0xB9, 0xCE, 0x73, 0x9D, 0xE7, 0x73, 0xDC, 0xFF,
  0x3F, 0xC7, 0x60, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0xE3, 0xF1, 0xF0,
  0x78, 0x3C, 0x1C, 0x00, 0xE7, 0x3F, 0x79, 0xFB, 0xDD, 0xDE, 0xEF, 0xFE,
  0x7D, 0xF3, 0xFF, 0x9F, 0xF8, 0xF7, 0xC7, 0xBC, 0x39, 0xE0, 0x3D, 0xE3,
  0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3C, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0xE3,
  0xDE, 0x00, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x76, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x81, 0xF0, 0x3C, 0x06, 0x00,
  0x1F, 0x9F, 0xCF, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x7F, 0x3F, 0x3F,
  0x80, 0x01, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x10, 0x38, 0x79, 0xF1, 0xC3, 0x87, 0x0F, 0x0E, 0x3C, 0xF1,
  0xC3, 0x8F, 0x3C, 0x78, 0xE0, 0x41, 0xF9, 0xFF, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 11, 14, 10, 0, -14 },
  { 37, 9, 15, 9, 0, -14 },
  { 54, 14, 14, 15, 1, -14 },
  { 79, 11, 14, 11, 0, -14 },
  { 99, 4, 5, 5, 2, -14 },
  { 102, 7, 17, 5, 0, -14 },
  { 117, 7, 17, 5, -2, -14 },
  { 132, 8, 9, 8, 1, -15 },
  { 141, 8, 9, 10, 1, -11 },
  { 150, 5, 6, 5, -1, -3 },
  { 154, 6, 3, 6, 0, -7 },
  { 157, 3, 3, 5, 0, -3 },
  { 159, 10, 14, 8, -1, -14 },
  { 177, 8, 14, 9, 1, -14 },
  { 191, 7, 14, 9, 2, -14 },
  { 204, 10, 14, 9, -1, -14 },
  { 222, 9, 14, 9, 0, -14 },
  { 238, 9, 14, 9, 0, -14 },
  { 254, 9, 14, 9, 0, -14 },
  { 270, 9, 14, 9, 1, -14 },
  { 286, 9, 14, 9, 1, -14 },
  { 302, 9, 14, 9, 0, -14 },
  { 318, 9, 14, 9, 0, -14 },
  { 334, 5, 11, 5, 0, -11 },
  { 341, 6, 14, 5, -1, -11 },
  { 352, 8, 10, 10, 1, -12 },
  { 362, 8, 7, 10, 1, -10 },
  { 369, 8, 10, 10, 1, -12 },
  { 379, 7, 14, 7, 1, -14 },
  { 392, 13, 15, 13, 0, -14 },
  { 417, 10, 14, 10, -1, -14 },
  { 435, 10, 14, 10, 0, -14 },
  { 453, 9, 14, 9, 1, -14 },
  { 469, 10, 14, 10, 0, -14 },
  { 487, 9, 14, 8, 0, -14 },
  { 503, 9, 14, 8, 0, -14 },
  { 519, 10, 14, 10, 1, -14 },
  { 537, 11, 14, 11, 0, -14 },
  { 557, 10, 14, 7, -1, -14 },
  { 575, 9, 18, 5, -3, -14 },
  { 596, 12, 14, 10, 0, -14 },
  { 617, 7, 14, 8, 0, -14 },
  { 630, 15, 14, 14, 0, -14 },
  { 657, 12, 14, 12, 0, -14 },
  { 678, 10, 14, 11, 1, -14 },
  { 696, 10, 14, 9, 0, -14 },
  { 714, 10, 17, 11, 1, -14 },
  { 736, 10, 14, 10, 0, -14 },
  { 754, 9, 14, 8, 0, -14 },
  { 770, 9, 14, 8, 1, -14 },
  { 786, 10, 14, 10, 1, -14 },
  { 804, 10, 14, 10, 2, -14 },
  { 822, 15, 14, 14, 1, -14 },
  { 849, 12, 14, 10, -1, -14 },
  { 870, 9, 14, 9, 2, -14 },
  { 886, 11, 14, 8, -1, -14 },
  { 906, 8, 17, 5, -1, -14 },
  { 923, 4, 14, 8, 2, -14 },
  { 930, 7, 17, 5, -1, -14 },
  { 945, 9, 9, 9, 0, -14 },
  { 956, 8, 3, 7, -2, 1 },
  { 959, 4, 3, 6, 3, -15 },
  { 961, 10, 11, 9, 0, -11 },
  { 975, 9, 14, 9, 0, -14 },
  { 991, 8, 11, 8, 0, -11 },
  { 1002, 10, 14, 9, 0, -14 },
  { 1020, 9, 11, 9, 0, -11 },
  { 1033, 10, 20, 6, -2, -15 },
  { 1058, 11, 16, 9, -1, -11 },
  { 1080, 9, 14, 9, 0, -14 },
  { 1096, 6, 15, 5, 0, -15 },
  { 1108, 8, 20, 5, -2, -15 },
  { 1128, 10, 14, 9, 0, -14 },
  { 1146, 6, 14, 5, 0, -14 },
  { 1157, 13, 11, 14, 0, -11 },
  { 1175, 9, 11, 9, 0, -11 },
  { 1188, 9, 11, 9, 0, -11 },
  { 1201, 10, 16, 9, -1, -11 },
  { 1221, 10, 16, 9, 0, -11 },
  { 1241, 8, 11, 7, 0, -11 },
  { 1252, 8, 11, 7, 0, -11 },
  { 1263, 6, 13, 7, 1, -13 },
  { 1273, 10, 11, 9, 0, -11 },
  { 1287, 9, 11, 9, 1, -11 },
  { 1300, 13, 11, 13, 1, -11 },
  { 1318, 11, 11, 9, -1, -11 },
  { 1334, 11, 16, 9, -1, -11 },
  { 1356, 9, 11, 7, -1, -11 },
  { 1369, 8, 17, 7, 0, -14 },
  { 1386, 3, 19, 7, 2, -15 },
  { 1394, 7, 17, 7, -1, -14 },
  { 1409, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC19PT7B_H_
