#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xFC, 0xFC, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x83, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7C, 0xF8,
  0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xB3, 0x81, 0xF6,
  0x20, 0x3E, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x6F,
  0x82, 0x0D, 0xF0, 0xE3, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x80,
  0xF8, 0x0F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0xF9, 0xE1, 0xF0, 0x1F,
  0x3C, 0x3C, 0x03, 0xC7, 0x8F, 0x80, 0xF9, 0xF1, 0xE0, 0x1F, 0x3E, 0x7C,
  0x03, 0xE7, 0xDF, 0x00, 0x7C, 0xF3, 0xE3, 0x8F, 0xBE, 0xF9, 0xFD, 0xFF,
  0x9F, 0x7F, 0xFF, 0xF7, 0xDF, 0xFB, 0xFC, 0xF3, 0xFF, 0x3F, 0x3E, 0xF9,
  0xE1, 0x07, 0x9F, 0x3C, 0x01, 0xF3, 0xC7, 0x80, 0x7C, 0xF8, 0xF0, 0x0F,
  0x9F, 0x3E, 0x03, 0xE3, 0xE7, 0xC0, 0x78, 0x7C, 0xF0, 0x1F, 0x0F, 0xBE,
  0x03, 0xC1, 0xFF, 0x80, 0xF8, 0x1F, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xCF, 0xE1, 0xFF, 0x9F, 0x87, 0xFF, 0x7F, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFC, 0xFF, 0xE3, 0xF9, 0xFF, 0xC7, 0xF1, 0xFF, 0x0F,
  0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0x3F, 0x3F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0x1F, 0x07, 0x3C, 0x3F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFC, 0x7F, 0x81, 0xFF,
  0x0F, 0xFF, 0x0F, 0xBF, 0x0F, 0x3F, 0x0C, 0x78, 0x08, 0xE0, 0x01, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C,
  0x7E, 0x3E, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFD, 0xFF, 0x80,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0x7E,
  0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF7, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x7E, 0x1F, 0xBF,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xF7, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF8, 0xFB, 0xF0, 0xE7, 0xE0, 0x9F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xF3, 0xF8, 0x1C, 0x7F, 0x02, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x71, 0xFC, 0x10,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x20, 0x1F, 0xCE, 0x0F, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E,
  0xFC, 0x0F, 0x3F, 0x07, 0xDF, 0xC3, 0xE7, 0xE0, 0xF1, 0xF8, 0x7C, 0x7E,
  0x1F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x80, 0xFE, 0x38, 0x7F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF3,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFD, 0xFC,
  0xFE, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3,
  0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xEF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x9F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xEF, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x73, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x88, 0x1F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x81, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x40, 0x0F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC6, 0x1F, 0x88, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0xF8, 0x70,
  0x7C, 0x7C, 0x7F, 0xCF, 0x1E, 0x3F, 0xF3, 0xCF, 0x9F, 0xFC, 0xF3, 0xCF,
  0x9F, 0x3D, 0xF3, 0xC7, 0x8F, 0x79, 0xF1, 0xE3, 0xDE, 0x78, 0x79, 0xEF,
  0x9E, 0x3E, 0x7B, 0xCF, 0x8F, 0x1E, 0xF3, 0xE3, 0xC7, 0xBC, 0xF9, 0xF3,
  0xCF, 0x3E, 0x7D, 0xF3, 0xCF, 0xFF, 0xF8, 0xF1, 0xFF, 0xFC, 0x3C, 0x7E,
  0x7E, 0x0F, 0x07, 0x0E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x1F,
  0x80, 0x70, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFB, 0xF0, 0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFB, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE7, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xF8,
  0x60, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x08,
  0x1F, 0xC7, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC3, 0x83, 0xFC,
  0x04, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF3, 0xFE, 0x3F, 0x9F, 0xF1, 0xFC, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x3F,
  0xC7, 0xF3, 0xFE, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xC1, 0xFC, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xF0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F,
  0x03, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F,
  0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF7, 0xDF, 0x83, 0xF7, 0xDF, 0xFE,
  0x0F, 0xDF, 0xFB, 0xF0, 0x3F, 0x7F, 0xEF, 0xC0, 0xFD, 0xFF, 0xBF, 0x03,
  0xF7, 0xFC, 0xFC, 0x1F, 0x9F, 0xF7, 0xF0, 0x7E, 0x7F, 0x9F, 0x81, 0xF9,
  0xFE, 0x7E, 0x07, 0xE7, 0xF1, 0xF8, 0x1F, 0x9F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0x7F,
  0x83, 0xF0, 0x7F, 0xE3, 0xF0, 0x3F, 0xF1, 0xF8, 0x1F, 0xF8, 0xFC, 0x0F,
  0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xDF, 0x81,
  0xFF, 0xEF, 0xC0, 0xFB, 0xF7, 0xE0, 0xFC, 0xFB, 0xE0, 0x7E, 0x7F, 0xF0,
  0x3F, 0x3F, 0xF8, 0x1F, 0x9F, 0xFC, 0x0F, 0xCF, 0xFE, 0x0F, 0xC7, 0xFE,
  0x07, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x81, 0xF8, 0x7F, 0xC0, 0xF8, 0x3F,
  0xE0, 0xFC, 0x1F, 0xE0, 0x7E, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xDF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xF1, 0xFB, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFE, 0xFF, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7E, 0x1F, 0xCF, 0xE1, 0xF9, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xF3, 0xC0, 0xFE, 0x08, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x40, 0x7F,
  0x07, 0x07, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0xBF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8,
  0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3,
  0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0x83, 0xFF, 0xF0, 0xFC, 0x1F, 0xBF,
  0x87, 0xE1, 0xFD, 0xF8, 0x3F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E, 0x7E, 0x1F,
  0xC7, 0xF3, 0xF1, 0xFE, 0x3F, 0x1F, 0x8F, 0xF1, 0xF8, 0xFC, 0x7F, 0x9F,
  0xC7, 0xE7, 0xFC, 0xFC, 0x3F, 0x3F, 0xEF, 0xE1, 0xFB, 0xFF, 0x7E, 0x0F,
  0xDF, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF,
  0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x03,
  0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFC, 0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0,
  0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xFF, 0x0F, 0xEF, 0xC3, 0xFB, 0xF1, 0xFC,
  0xFE, 0x7E, 0x3F, 0xBF, 0x87, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0,
  0x1F, 0xBE, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF0, 0x3E, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF0, 0x7C,
  0x07, 0xC7, 0xC3, 0xFB, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F,
  0xCF, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0xFF, 0x0F, 0xCF, 0x80, 0x03, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE1, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x04, 0x7E, 0x18, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xCF, 0xC0,
  0xFE, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xF3, 0xF8,
  0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xF7, 0xC0, 0x7E,
  0x7C, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF,
  0x3F, 0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE4, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x9F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x3F, 0xBF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0xFE, 0x1F, 0x8F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x87, 0xF3, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x08, 0x07, 0xE0, 0xC0, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0xFB, 0xF8, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF, 0xC3, 0xF1, 0xF8, 0xFE, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC7, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF0, 0x03, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x9F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x07,
  0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xCF, 0xC7, 0xE0,
  0x7D, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFE, 0xFF, 0x7F, 0x0F, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x7F,
  0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x80, 0x07, 0xCF,
  0x80, 0xFB, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF,
  0xC3, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x7F, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9,
  0xF9, 0xF8, 0xFE, 0xFC, 0x7F, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF,
  0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF9, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xE7, 0xC0,
  0x3E, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F,
  0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1, 0xFD,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF3, 0xE0, 0xFE, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7,
  0xF3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xF7, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x9E, 0x1F, 0x7C, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xF1, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3,
  0xFF, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x20, 0x7E, 0x61, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFD, 0xF0, 0x7E, 0x7C,
  0x00, 0xFC, 0x1F, 0xFF, 0x0F, 0xEF, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E,
  0x1F, 0x1F, 0x87, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x7E, 0x07,
  0xDF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xC7, 0xEF, 0xC7, 0xF1, 0xFB, 0xF3,
  0xFC, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0x3F, 0xCF, 0xCF, 0xDF, 0xF7, 0xE3,
  0xF7, 0xFD, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF,
  0xC3, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x5F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xBF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 27, 10, 0, -27 },
  { 42, 16, 10, 17, 3, -27 },
  { 62, 21, 27, 20, 0, -27 },
  { 133, 19, 31, 18, 0, -29 },
  { 207, 27, 28, 30, 2, -28 },
  { 302, 23, 27, 23, 0, -27 },
  { 380, 8, 10, 9, 3, -27 },
  { 390, 14, 34, 11, 0, -28 },
  { 450, 13, 34, 11, -3, -28 },
  { 506, 15, 18, 17, 3, -29 },
  { 540, 16, 19, 19, 2, -23 },
  { 578, 9, 11, 10, -2, -6 },
  { 591, 11, 6, 12, 0, -13 },
  { 600, 7, 7, 10, 0, -7 },
  { 607, 21, 28, 15, -2, -28 },
  { 681, 17, 28, 18, 1, -28 },
  { 741, 15, 27, 18, 3, -27 },
  { 792, 19, 28, 18, -1, -28 },
  { 859, 18, 28, 18, 0, -28 },
  { 922, 18, 27, 18, 0, -27 },
  { 983, 18, 27, 18, 1, -27 },
  { 1044, 18, 28, 18, 1, -28 },
  { 1107, 19, 27, 18, 1, -27 },
  { 1172, 19, 28, 18, 0, -28 },
  { 1239, 18, 28, 18, 0, -28 },
  { 1302, 10, 21, 10, 0, -21 },
  { 1329, 12, 26, 10, -2, -21 },
  { 1368, 17, 19, 19, 1, -23 },
  { 1409, 16, 13, 19, 2, -20 },
  { 1435, 16, 19, 19, 2, -23 },
  { 1473, 15, 28, 14, 1, -28 },
  { 1526, 26, 30, 27, 1, -27 },
  { 1624, 20, 27, 20, -2, -27 },
  { 1692, 20, 27, 20, 0, -27 },
  { 1760, 19, 28, 18, 1, -28 },
  { 1827, 21, 27, 21, 0, -27 },
  { 1898, 18, 27, 16, 0, -27 },
  { 1959, 18, 27, 15, 0, -27 },
  { 2020, 21, 28, 21, 1, -28 },
  { 2094, 23, 27, 21, 0, -27 },
  { 2172, 18, 27, 14, -1, -27 },
  { 2233, 18, 36, 10, -6, -27 },
  { 2314, 23, 27, 19, 0, -27 },
  { 2392, 14, 27, 15, 0, -27 },
  { 2440, 30, 27, 28, 0, -27 },
  { 2542, 25, 27, 23, 0, -27 },
  { 2627, 21, 28, 22, 1, -28 },
  { 2701, 19, 27, 18, 0, -27 },
  { 2766, 21, 34, 22, 1, -28 },
  { 2856, 20, 27, 19, 0, -27 },
  { 2924, 20, 28, 17, -1, -28 },
  { 2994, 16, 27, 16, 3, -27 },
  { 3048, 21, 27, 21, 1, -27 },
  { 3119, 19, 27, 20, 4, -27 },
  { 3184, 29, 27, 28, 3, -27 },
  { 3282, 24, 27, 19, -2, -27 },
  { 3363, 18, 27, 19, 4, -27 },
  { 3424, 20, 27, 17, -1, -27 },
  { 3492, 16, 34, 11, -2, -28 },
  { 3560, 9, 28, 15, 4, -28 },
  { 3592, 16, 34, 11, -3, -28 },
  { 3660, 19, 18, 18, -1, -27 },
  { 3703, 16, 5, 15, -4, 2 },
  { 3713, 9, 6, 13, 5, -29 },
  { 3720, 18, 21, 19, 1, -21 },
  { 3768, 19, 29, 19, -1, -29 },
  { 3837, 15, 21, 15, 1, -21 },
  { 3877, 20, 29, 19, 1, -29 },
  { 3950, 16, 21, 18, 1, -21 },
  { 3992, 20, 38, 12, -4, -29 },
  { 4087, 20, 30, 19, -1, -21 },
  { 4162, 19, 29, 19, -1, -29 },
  { 4231, 12, 29, 10, 0, -29 },
  { 4275, 17, 38, 10, -5, -29 },
  { 4356, 22, 29, 18, -1, -29 },
  { 4436, 13, 29, 10, -1, -29 },
  { 4484, 28, 21, 28, -1, -21 },
  { 4558, 19, 21, 19, -1, -21 },
  { 4608, 17, 21, 18, 1, -21 },
  { 4653, 20, 30, 19, -2, -21 },
  { 4728, 19, 30, 19, 0, -21 },
  { 4800, 15, 21, 13, 0, -21 },
  { 4840, 15, 21, 15, 0, -21 },
  { 4880, 13, 25, 13, 1, -25 },
  { 4921, 18, 21, 19, 1, -21 },
  { 4969, 18, 21, 17, 2, -21 },
  { 5017, 26, 21, 26, 2, -21 },
  { 5086, 21, 21, 17, -2, -21 },
  { 5142, 22, 30, 17, -2, -21 },
  { 5225, 18, 21, 15, -2, -21 },
  { 5273, 16, 33, 13, 0, -27 },
  { 5339, 5, 38, 15, 5, -29 },
  { 5363, 15, 33, 13, -2, -27 },
  { 5425, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC38PT7B_H_
