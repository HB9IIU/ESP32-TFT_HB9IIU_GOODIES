#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x29, 0x80, 0xFA, 0x2B, 0xD5, 0xE6, 0x50, 0x27, 0x66, 0x3F,
  0x64, 0x20, 0xD9, 0xA7, 0xB5, 0xA5, 0x5B, 0x00, 0x13, 0x9C, 0xDF, 0xFB,
  0xE0, 0xE0, 0x2D, 0x2D, 0x26, 0x24, 0x92, 0x5E, 0x5D, 0x50, 0x2F, 0x22,
  0x78, 0xE0, 0xB0, 0x08, 0x44, 0x62, 0x33, 0x00, 0x27, 0x55, 0xDF, 0x60,
  0x7F, 0xA5, 0x80, 0x27, 0x53, 0x6D, 0xE0, 0x27, 0x16, 0x3B, 0xE0, 0x33,
  0x7B, 0xF2, 0x74, 0x73, 0xBE, 0x19, 0x90, 0xED, 0x79, 0x80, 0x78, 0x8C,
  0x46, 0x60, 0x27, 0x56, 0xFF, 0xE0, 0x27, 0x57, 0x72, 0xE0, 0x52, 0xC0,
  0x24, 0x07, 0x80, 0x3E, 0x71, 0xF0, 0xF0, 0xC3, 0x78, 0x27, 0x36, 0x44,
  0xC0, 0x18, 0x95, 0xEB, 0xBE, 0xEC, 0x8C, 0x19, 0xCA, 0x77, 0xE4, 0x7A,
  0xDD, 0xAF, 0x78, 0x13, 0xD1, 0x8C, 0x69, 0xC0, 0x7A, 0xD7, 0xBF, 0x70,
  0x74, 0x7C, 0xCE, 0x74, 0x7E, 0xCC, 0x13, 0xD8, 0xBF, 0xE9, 0xC0, 0x6A,
  0x5F, 0xBD, 0x68, 0x76, 0x64, 0x4E, 0x32, 0x22, 0x66, 0x4C, 0x7D, 0x47,
  0x3C, 0xF3, 0xC0, 0x69, 0x6D, 0xC0, 0x66, 0xDD, 0xB7, 0xEF, 0x57, 0x80,
  0x6D, 0xA7, 0xBE, 0xDA, 0x60, 0x13, 0xD3, 0x9D, 0xE9, 0xC0, 0x7A, 0xD5,
  0xEC, 0x60, 0x13, 0xD3, 0x9D, 0xE9, 0xC6, 0x30, 0x7A, 0xDD, 0xEF, 0x78,
  0x27, 0x46, 0x3B, 0xE0, 0xF4, 0xCC, 0x88, 0x6A, 0xD7, 0xAD, 0x38, 0x9D,
  0xA9, 0xCC, 0x60, 0xB7, 0x7B, 0xE7, 0xCF, 0x96, 0x00, 0x3C, 0xE3, 0x0C,
  0x7B, 0x60, 0xBE, 0xEC, 0xCC, 0x79, 0x98, 0x8D, 0x70, 0x6D, 0x2D, 0x26,
  0xC0, 0xAB, 0xD4, 0x33, 0x32, 0x22, 0x66, 0xC0, 0x37, 0x59, 0xF0, 0xD0,
  0x7A, 0xB5, 0xEF, 0x00, 0x64, 0x75, 0xDF, 0xE0, 0x74, 0xCE, 0xE0, 0x18,
  0xDC, 0xAD, 0x7B, 0xC0, 0x75, 0xFC, 0xE0, 0x19, 0x9C, 0x42, 0x31, 0x88,
  0xC0, 0x7A, 0xB5, 0xEF, 0x13, 0x80, 0x64, 0x75, 0xDF, 0xB0, 0x69, 0x2D,
  0xA0, 0x32, 0x22, 0x66, 0x44, 0xC0, 0x62, 0x16, 0xEE, 0x7A, 0xC0, 0x69,
  0x2D, 0xA0, 0x7D, 0x5D, 0x7F, 0xBC, 0x75, 0xDF, 0xB0, 0x75, 0xDF, 0xE0,
  0x39, 0x5A, 0xF7, 0x23, 0x00, 0x7A, 0xB5, 0xEF, 0x10, 0x80, 0x76, 0xCC,
  0x80, 0x7C, 0x6A, 0xE0, 0x2F, 0x2D, 0xC0, 0x5A, 0xB5, 0xEF, 0x00, 0xBE,
  0xCC, 0xC0, 0x56, 0xE9, 0xF7, 0xCD, 0x80, 0x5B, 0x99, 0xCB, 0x00, 0x2C,
  0xE3, 0x0C, 0x30, 0x8C, 0x00, 0x7A, 0x6C, 0xE0, 0x36, 0x68, 0x44, 0xC0,
  0xFF, 0x80, 0x33, 0x21, 0x26, 0xC0, 0xFB,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 2, 2, 2, 1, -6 },
  { 26, 3, 8, 3, 0, -7 },
  { 29, 3, 8, 3, -1, -7 },
  { 32, 3, 4, 4, 1, -7 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 3, 2, 2, -1, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 2, 2, 0, -2 },
  { 39, 5, 7, 4, -1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 3, 6, 4, 1, -6 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 5, 7, 4, 0, -7 },
  { 70, 5, 6, 4, 0, -6 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 4, 7, 4, 0, -7 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 3, 6, 2, -1, -5 },
  { 87, 4, 4, 5, 0, -5 },
  { 89, 4, 3, 5, 0, -5 },
  { 91, 4, 4, 5, 0, -5 },
  { 93, 4, 7, 3, 0, -7 },
  { 97, 6, 8, 6, 0, -7 },
  { 103, 5, 6, 5, -1, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 7, 4, 0, -7 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 4, 6, 4, 0, -6 },
  { 123, 4, 6, 4, 0, -6 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 4, 6, 3, 0, -6 },
  { 138, 4, 8, 2, -1, -6 },
  { 142, 6, 6, 5, 0, -6 },
  { 147, 3, 6, 4, 0, -6 },
  { 150, 7, 6, 7, 0, -6 },
  { 156, 6, 6, 5, 0, -6 },
  { 161, 5, 7, 5, 0, -7 },
  { 166, 5, 6, 4, 0, -6 },
  { 170, 5, 9, 5, 0, -7 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 7, 4, 0, -7 },
  { 184, 4, 6, 4, 1, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 5, 6, 5, 1, -6 },
  { 195, 7, 6, 7, 1, -6 },
  { 201, 6, 6, 5, -1, -6 },
  { 206, 4, 6, 4, 1, -6 },
  { 209, 5, 6, 4, 0, -6 },
  { 213, 3, 9, 3, 0, -7 },
  { 217, 2, 7, 4, 1, -7 },
  { 219, 4, 9, 3, -1, -7 },
  { 224, 4, 4, 4, 0, -6 },
  { 226, 4, 1, 3, -1, 1 },
  { 227, 2, 2, 3, 1, -7 },
  { 228, 5, 5, 4, 0, -5 },
  { 232, 4, 7, 4, 0, -7 },
  { 236, 4, 5, 4, 0, -5 },
  { 239, 5, 7, 4, 0, -7 },
  { 244, 4, 5, 4, 0, -5 },
  { 247, 5, 9, 3, -1, -7 },
  { 253, 5, 7, 4, 0, -5 },
  { 258, 4, 7, 4, 0, -7 },
  { 262, 3, 7, 2, 0, -7 },
  { 265, 4, 9, 2, -1, -7 },
  { 270, 5, 7, 4, 0, -7 },
  { 275, 3, 7, 2, 0, -7 },
  { 278, 6, 5, 7, 0, -5 },
  { 282, 4, 5, 4, 0, -5 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 5, 7, 4, -1, -5 },
  { 293, 5, 7, 4, 0, -5 },
  { 298, 4, 5, 3, 0, -5 },
  { 301, 4, 5, 3, 0, -5 },
  { 304, 3, 6, 3, 0, -6 },
  { 307, 5, 5, 4, 0, -5 },
  { 311, 4, 5, 4, 1, -5 },
  { 314, 7, 5, 6, 0, -5 },
  { 319, 5, 5, 4, 0, -5 },
  { 323, 6, 7, 4, -1, -5 },
  { 329, 4, 5, 4, 0, -5 },
  { 332, 4, 7, 3, 0, -6 },
  { 336, 1, 9, 4, 1, -7 },
  { 338, 4, 7, 3, -1, -6 },
  { 342, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC9PT7B_H_
