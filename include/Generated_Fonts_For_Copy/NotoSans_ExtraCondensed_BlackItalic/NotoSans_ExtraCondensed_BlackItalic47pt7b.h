#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01,
  0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFE,
  0xCF, 0x03, 0xF7, 0x08, 0x1F, 0xDC, 0x00, 0x7F, 0x60, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1B,
  0xF8, 0x40, 0x6F, 0xE1, 0x83, 0xBF, 0x87, 0x0E, 0xFC, 0x1F, 0x37, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xC0, 0x7C, 0x01, 0xFB, 0xF0, 0x7E, 0x01, 0xF9, 0xF8, 0x7E, 0x00,
  0xF8, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x1F, 0x80,
  0x3F, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x8F, 0xC0, 0x0F, 0x8F, 0xCF, 0xC0,
  0x07, 0xC7, 0xC7, 0xC1, 0xC3, 0xE7, 0xE7, 0xE3, 0xF9, 0xF3, 0xF7, 0xE3,
  0xFE, 0xFF, 0xF3, 0xF3, 0xFF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0xF9, 0xFB,
  0xFF, 0xEF, 0xF9, 0xF9, 0xF9, 0xF1, 0xF0, 0xF9, 0xF8, 0xF8, 0x00, 0xFC,
  0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x3F, 0x00, 0x7E,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC7, 0xC0, 0x1F,
  0x87, 0xE7, 0xE0, 0x1F, 0x83, 0xF3, 0xE0, 0x0F, 0x81, 0xFF, 0xF0, 0x0F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF,
  0x03, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8, 0xFE, 0x0F, 0xFF, 0xDF, 0xE1, 0xFF,
  0xFD, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF,
  0x87, 0xF1, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF,
  0x07, 0xFC, 0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0x80,
  0xFF, 0x8F, 0xFC, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x30, 0xFC, 0x03, 0xCF, 0xC2, 0x7E, 0xF8, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xBF, 0x03, 0xF3, 0xF8, 0x1F,
  0x3F, 0xC0, 0xE1, 0xE0, 0x04, 0x1C, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF9, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7, 0xFB,
  0xF9, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE,
  0x3F, 0x87, 0xF3, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC, 0xFE, 0x1F, 0xE7,
  0xF0, 0xFF, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0x1F,
  0xE7, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7E, 0xFF, 0x0F, 0x3F, 0xC1, 0x8F, 0xE0, 0x47,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xF8, 0xFF, 0x01, 0xE1, 0xFE, 0x03, 0x03, 0xFC, 0x02,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xC1, 0xFF, 0x01, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF1, 0x00, 0x3F, 0xC3, 0x00,
  0xFF, 0x87, 0xC7, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0xFB, 0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F,
  0x1F, 0xC0, 0x7E, 0x7F, 0x81, 0xF8, 0xFF, 0x07, 0xE1, 0xFE, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x02, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE2, 0x00, 0xFF, 0x0C,
  0x07, 0xFC, 0x3E, 0x3F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0xFC, 0x07,
  0xFB, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC7, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFE, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0,
  0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7,
  0xF9, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xF7, 0xF0, 0x1E, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE1, 0x03, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x04, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0xFF, 0x08, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x60, 0x1F, 0x0F, 0xC3, 0xFF, 0x1F, 0x0F, 0x87, 0xFF, 0x9F, 0x1F, 0x8F,
  0xFF, 0x9F, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0x1F, 0x9F, 0x1F, 0x3E, 0x3F,
  0x1F, 0x1F, 0x3E, 0x3E, 0x1F, 0x1F, 0x7C, 0x7E, 0x3F, 0x1F, 0x7C, 0x7C,
  0x3E, 0x1F, 0x7C, 0x7C, 0x3E, 0x1E, 0x7C, 0xFC, 0x3E, 0x3E, 0xF8, 0xFC,
  0x7E, 0x3E, 0xF8, 0xF8, 0x7E, 0x3C, 0xF8, 0xF8, 0x7C, 0x7C, 0xF8, 0xFC,
  0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F,
  0xBF, 0xE0, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x0C, 0x06, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x3F, 0xC0,
  0x3E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0xFF,
  0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x18, 0x1F, 0xF0, 0x10, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x04, 0x07, 0xFE, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFE,
  0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xE1, 0xFF, 0x07, 0xF8,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x1C, 0x1F, 0xF8,
  0x04, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0x1F, 0xFC, 0xFF,
  0x8F, 0xFE, 0x7F, 0xCF, 0xFE, 0x3F, 0xC7, 0xFF, 0x1F, 0xE3, 0xFF, 0x8F,
  0xF1, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF9, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x01, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x0F,
  0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xDF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F,
  0xFE, 0x3F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xBF,
  0x80, 0xFF, 0xFC, 0xFD, 0xFC, 0x07, 0xF7, 0xEF, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFE, 0xFF, 0x01, 0xFD, 0xFF, 0xF7, 0xF0, 0x1F, 0xEF, 0xFF, 0x3F, 0x80,
  0xFF, 0x7F, 0xFB, 0xFC, 0x07, 0xF3, 0xFF, 0x9F, 0xE0, 0x3F, 0x9F, 0xFC,
  0xFF, 0x01, 0xFC, 0xFF, 0xE7, 0xF0, 0x1F, 0xE7, 0xFE, 0x3F, 0x80, 0xFF,
  0x3F, 0xF3, 0xFC, 0x07, 0xF1, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFC,
  0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x03,
  0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0x81, 0xFF,
  0xE1, 0xFE, 0x07, 0xFF, 0x87, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF8,
  0x7F, 0x01, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x3F,
  0xC0, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xCF, 0xE0,
  0x7F, 0x3F, 0xFF, 0x81, 0xFC, 0xFF, 0xFE, 0x07, 0xF3, 0xFF, 0xF0, 0x1F,
  0xCF, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0x03, 0xFC, 0xFF, 0xFC, 0x0F, 0xE1,
  0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0x80, 0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0x7F,
  0xF8, 0x1F, 0xE1, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF,
  0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x83,
  0xFE, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xF3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC,
  0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xFC,
  0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xE0,
  0x3F, 0x9F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x7F, 0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFC, 0x7C, 0x07, 0xF8, 0x18, 0x07, 0xF8, 0x08, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x40, 0x1F, 0xF0, 0x30, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F,
  0xF3, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF1, 0xFE, 0x03, 0xF8,
  0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F,
  0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F,
  0xC0, 0xFF, 0x7F, 0x81, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xFC, 0x3F,
  0xC7, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x8F, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0xC7, 0xF8, 0x7F, 0x0F, 0xFC, 0x7F, 0x87, 0xF1, 0xFF, 0xCF, 0xF0, 0x7F,
  0x1F, 0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F, 0xF9, 0xFE,
  0x07, 0xF7, 0xFF, 0x9F, 0xE0, 0x7F, 0x7F, 0xFB, 0xFC, 0x07, 0xF7, 0xFF,
  0xBF, 0xC0, 0x7F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x7F,
  0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xF0,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0xFF, 0x07, 0xFD, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xE7, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0,
  0x7F, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x1F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x3F, 0xC7, 0xF8, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F,
  0xF7, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFB,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8,
  0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x87,
  0xF9, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xEF, 0xE0, 0x7F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xF9, 0xFE,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x61, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x18, 0x7F, 0x8F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F,
  0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x87, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFE,
  0x07, 0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xEF, 0xE0, 0x1F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x7F, 0x87, 0xF7, 0xF8, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x10, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xD8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x9F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0xBF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x04, 0x01, 0xFE, 0x03, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x9F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0xFD, 0xFF, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xBF, 0xFB, 0xFC, 0x3F, 0xC7, 0xFC, 0xFF,
  0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE,
  0x7F, 0x87, 0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87,
  0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xDF,
  0xE1, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF9, 0xFE, 0x7F,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x80,
  0x7F, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xE7, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xE3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x87, 0xF9, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xBF,
  0x80, 0x7E, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF1, 0xF0, 0x3F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x60, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE2,
  0x03, 0xFC, 0x70, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x10, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xFD, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0x3F, 0x00,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE1,
  0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0x87,
  0xF3, 0xFC, 0x3F, 0x9F, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF8,
  0x7F, 0x7F, 0x0F, 0xF8, 0xFF, 0x7F, 0x1F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF8,
  0xFE, 0x7F, 0x1F, 0xF9, 0xFE, 0x7F, 0x3F, 0xF9, 0xFC, 0x7F, 0x3F, 0xF1,
  0xFC, 0x7F, 0x3F, 0xF3, 0xF8, 0x7F, 0x7F, 0xF3, 0xF8, 0x7F, 0x7F, 0xF7,
  0xF8, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xF7, 0xF0, 0x7E, 0xFF, 0xF7,
  0xE0, 0x7E, 0xFB, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF,
  0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF,
  0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xF0, 0x07, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 15, 35, 12, 0, -34 },
  { 67, 20, 13, 21, 4, -34 },
  { 100, 26, 34, 25, 0, -34 },
  { 211, 22, 39, 22, 1, -36 },
  { 319, 33, 34, 37, 3, -34 },
  { 460, 28, 34, 28, 0, -34 },
  { 579, 10, 13, 11, 4, -34 },
  { 596, 16, 42, 13, 1, -35 },
  { 680, 17, 42, 13, -4, -35 },
  { 770, 20, 22, 21, 3, -36 },
  { 825, 20, 23, 24, 2, -28 },
  { 883, 12, 14, 12, -3, -7 },
  { 904, 14, 7, 14, 0, -16 },
  { 917, 9, 9, 12, 0, -8 },
  { 928, 26, 34, 19, -3, -34 },
  { 1039, 21, 34, 22, 1, -34 },
  { 1129, 18, 34, 22, 4, -34 },
  { 1206, 23, 34, 22, -1, -34 },
  { 1304, 23, 34, 22, 0, -34 },
  { 1402, 23, 34, 22, 0, -34 },
  { 1500, 22, 34, 22, 1, -34 },
  { 1594, 23, 34, 22, 1, -34 },
  { 1692, 24, 34, 22, 1, -34 },
  { 1794, 23, 34, 22, 0, -34 },
  { 1892, 21, 34, 22, 1, -34 },
  { 1982, 13, 27, 13, 0, -26 },
  { 2026, 16, 33, 13, -3, -26 },
  { 2092, 20, 24, 24, 2, -29 },
  { 2152, 20, 17, 24, 2, -25 },
  { 2195, 21, 24, 24, 2, -29 },
  { 2258, 19, 35, 18, 1, -34 },
  { 2342, 32, 38, 33, 1, -34 },
  { 2494, 25, 34, 25, -3, -34 },
  { 2601, 25, 34, 24, 0, -34 },
  { 2708, 23, 34, 22, 2, -34 },
  { 2806, 26, 34, 26, 0, -34 },
  { 2917, 22, 34, 20, 0, -34 },
  { 3011, 22, 34, 19, 0, -34 },
  { 3105, 25, 34, 26, 2, -34 },
  { 3212, 28, 34, 26, 0, -34 },
  { 3331, 23, 34, 18, -2, -34 },
  { 3429, 22, 45, 13, -7, -34 },
  { 3553, 29, 34, 24, 0, -34 },
  { 3677, 17, 34, 19, 0, -34 },
  { 3750, 37, 34, 35, 0, -34 },
  { 3908, 30, 34, 28, 0, -34 },
  { 4036, 25, 34, 27, 2, -34 },
  { 4143, 24, 34, 23, 0, -34 },
  { 4245, 25, 42, 27, 2, -34 },
  { 4377, 24, 34, 24, 0, -34 },
  { 4479, 24, 34, 20, -1, -34 },
  { 4581, 21, 34, 20, 3, -34 },
  { 4671, 26, 34, 26, 2, -34 },
  { 4782, 25, 34, 24, 4, -34 },
  { 4889, 36, 34, 35, 3, -34 },
  { 5042, 30, 34, 24, -3, -34 },
  { 5170, 23, 34, 23, 4, -34 },
  { 5268, 26, 34, 21, -2, -34 },
  { 5379, 19, 43, 13, -2, -35 },
  { 5482, 11, 34, 19, 5, -34 },
  { 5529, 20, 43, 13, -4, -35 },
  { 5637, 23, 23, 22, -1, -34 },
  { 5704, 20, 6, 18, -5, 3 },
  { 5719, 10, 8, 16, 7, -36 },
  { 5729, 23, 26, 23, 1, -26 },
  { 5804, 23, 36, 23, -1, -36 },
  { 5908, 19, 26, 19, 1, -26 },
  { 5970, 25, 36, 23, 1, -36 },
  { 6083, 20, 26, 22, 1, -26 },
  { 6148, 25, 47, 15, -5, -36 },
  { 6295, 25, 37, 23, -1, -26 },
  { 6411, 23, 36, 23, -1, -36 },
  { 6515, 15, 36, 12, -1, -36 },
  { 6583, 20, 47, 12, -6, -36 },
  { 6701, 26, 36, 23, -1, -36 },
  { 6818, 16, 36, 12, -1, -36 },
  { 6890, 34, 26, 34, -1, -26 },
  { 7001, 23, 26, 23, -1, -26 },
  { 7076, 21, 26, 23, 1, -26 },
  { 7145, 25, 37, 23, -3, -26 },
  { 7261, 23, 37, 23, 1, -26 },
  { 7368, 20, 26, 17, -1, -26 },
  { 7433, 19, 26, 18, 0, -26 },
  { 7495, 16, 31, 16, 2, -31 },
  { 7557, 23, 26, 23, 1, -26 },
  { 7632, 21, 26, 21, 3, -26 },
  { 7701, 32, 26, 32, 2, -26 },
  { 7805, 26, 26, 22, -2, -26 },
  { 7890, 27, 37, 21, -3, -26 },
  { 8015, 22, 26, 18, -2, -26 },
  { 8087, 20, 41, 16, 0, -34 },
  { 8190, 6, 47, 18, 6, -36 },
  { 8226, 19, 41, 16, -3, -34 },
  { 8324, 21, 9, 24, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC47PT7B_H_
