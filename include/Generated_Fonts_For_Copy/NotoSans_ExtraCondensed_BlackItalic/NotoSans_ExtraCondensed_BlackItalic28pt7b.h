#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E, 0x1E, 0x00,
  0x7B, 0xFF, 0x7F, 0xEF, 0xF9, 0xEF, 0x3D, 0xE7, 0xBD, 0xE0, 0x01, 0xCE,
  0x03, 0xDE, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0xBC, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFE, 0x3F, 0xFE, 0x0E, 0x70, 0x0E, 0x70, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0x39, 0xC0, 0x39, 0xC0, 0x7B, 0xC0, 0x73, 0x80,
  0x73, 0x80, 0x00, 0x40, 0x03, 0x00, 0x3F, 0x83, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE1, 0xF9, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xC4, 0x2F, 0x19, 0xBC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x0F,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x1E, 0x07, 0x83, 0xF0, 0x70,
  0x7F, 0x0F, 0x0F, 0x79, 0xE0, 0xF7, 0x1C, 0x0E, 0x73, 0xC0, 0xE7, 0x38,
  0x0E, 0x77, 0x80, 0xEF, 0x73, 0xCF, 0xEF, 0x7E, 0xFC, 0xEF, 0xE7, 0x9C,
  0xEF, 0x03, 0xDE, 0xF0, 0x39, 0xCE, 0x07, 0x9C, 0xE0, 0x71, 0xCE, 0x0F,
  0x1D, 0xE0, 0xE1, 0xFC, 0x1E, 0x1F, 0x83, 0xC0, 0xF0, 0x01, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE7, 0xCF, 0xF3, 0xC7, 0xFF, 0xE7, 0xFF,
  0xE7, 0xCF, 0xF3, 0xE7, 0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xEF, 0xC0, 0x7F, 0xFF, 0xEF, 0x7B, 0xC0, 0x03, 0xC0, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0,
  0x00, 0x08, 0x80, 0xF0, 0x0F, 0x06, 0xF0, 0x7F, 0x6F, 0xFE, 0xFF, 0xE1,
  0xFF, 0x3F, 0x07, 0xF8, 0xFB, 0xC3, 0x3C, 0x13, 0x00, 0x20, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x7C, 0xF9, 0xE3, 0xCF,
  0x1E, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xFF, 0x3E, 0xF3, 0xCF,
  0x7C, 0xF7, 0xCF, 0x78, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1, 0xEF, 0x3E,
  0xF3, 0xEF, 0x3C, 0xFF, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x01, 0xE0, 0x7C,
  0x1F, 0x8F, 0xF3, 0xFC, 0xFF, 0xBF, 0xF3, 0xBE, 0x27, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0E, 0x7C, 0x11, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8,
  0x07, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x87, 0x80, 0x3C, 0x03, 0xE0,
  0x3E, 0x0F, 0xE0, 0x7C, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xD0, 0x7C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xBC, 0x1F,
  0xF0, 0x77, 0xC3, 0x9E, 0x1E, 0x78, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC3, 0xFF,
  0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x90, 0xF8, 0xFF, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xE1,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0xF8, 0x7F, 0xE7, 0xFF, 0x3F, 0xFD, 0xF3,
  0xEF, 0x9F, 0x7C, 0xF3, 0xCF, 0x9F, 0x7C, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xDF, 0x1E, 0x7C, 0x79, 0xE1,
  0xEF, 0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x7D, 0xF1,
  0xE7, 0xCF, 0x8F, 0x3E, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0,
  0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xE7, 0x9F, 0x3C, 0xF9, 0xE7,
  0x9F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE1, 0xEF, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x06, 0x3C, 0xF9,
  0xF3, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0x3E, 0x78, 0x01,
  0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x00, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFC, 0x0F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0x1F, 0xF7,
  0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0x9F,
  0xF2, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x79,
  0xFD, 0xCE, 0x7F, 0x3B, 0x9E, 0xE7, 0x73, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C,
  0xF7, 0x77, 0x9C, 0xEE, 0xF3, 0x9D, 0xDE, 0xF7, 0x3B, 0xFF, 0xE7, 0x3F,
  0xF8, 0xE3, 0x0C, 0x1C, 0x00, 0x03, 0xC0, 0x20, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3C, 0x3E,
  0x78, 0x7C, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3E, 0x3E,
  0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F, 0x3E, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C,
  0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0x87, 0xFE, 0x3F, 0x10, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x10,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xF7, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3C,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE1, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xF0,
  0x87, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7D, 0xFD, 0xF3, 0xFB, 0xE7, 0xF7,
  0xCF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xFF, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0x87, 0x8F, 0x83, 0xCF,
  0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7B, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81,
  0xF7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E, 0x1F, 0x1F,
  0x00, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xF7, 0x7F, 0xC3, 0xDD, 0xFF, 0x0F, 0x77, 0x78, 0x7D,
  0xFD, 0xE1, 0xF7, 0xEF, 0x87, 0x9F, 0xBE, 0x1E, 0x7E, 0xF8, 0x79, 0xF3,
  0xC3, 0xE7, 0xCF, 0x0F, 0x9E, 0x7C, 0x3C, 0x79, 0xF0, 0x0F, 0x83, 0xC3,
  0xF1, 0xF0, 0xFC, 0x7C, 0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF3, 0xE1, 0xFC,
  0xF8, 0xFF, 0xBE, 0x3F, 0xEF, 0x0F, 0x7B, 0xC3, 0xDE, 0xF0, 0xF7, 0xFC,
  0x7D, 0xFE, 0x1F, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x3E,
  0x3F, 0x0F, 0x8F, 0xC3, 0xC1, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x7C, 0xFC,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x7D, 0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x7C,
  0xFC, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE1, 0xF7, 0xE3, 0xE7, 0xC7, 0x9F, 0x1F, 0x3E, 0x3E, 0xFC, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3C, 0xF8,
  0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xE7, 0xC7, 0xC0, 0x03, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE1, 0xF9, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x10, 0x7C,
  0x38, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xFF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0x1F, 0x1E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xE1,
  0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0xBC,
  0x3E, 0xF1, 0xF3, 0xC7, 0xCF, 0x3E, 0x3C, 0xF8, 0xF3, 0xC3, 0xDF, 0x0F,
  0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x78, 0x7B, 0xC7, 0xC7, 0xFE, 0x3E,
  0x3F, 0xF1, 0xF3, 0xEF, 0x9F, 0x9F, 0x7C, 0xFC, 0xF3, 0xEF, 0xEF, 0x9F,
  0x7F, 0x7C, 0xFB, 0xFB, 0xC7, 0xFF, 0xFE, 0x3F, 0xFD, 0xE1, 0xFE, 0xEF,
  0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x7C,
  0x0F, 0x9F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFF, 0xCF, 0xBE, 0x7D,
  0xF7, 0xCF, 0xBE, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x9E,
  0x79, 0xE7, 0x9E, 0x78, 0xE3, 0xCF, 0x3C, 0xF3, 0xCF, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0x00, 0x60, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0x83, 0xDE, 0x1F, 0x78, 0x79, 0xE3, 0xC3, 0xCF, 0x0F, 0xF8, 0x3C, 0x7F,
  0xF7, 0xFE, 0xFF, 0xE0, 0xF9, 0xE3, 0xCF, 0x07, 0x00, 0x3E, 0xF1, 0xFF,
  0xCF, 0xFE, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3,
  0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0x78, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x30, 0x7F, 0xC3, 0xFF,
  0x3F, 0xF9, 0xF7, 0xCF, 0x9E, 0x78, 0xF7, 0xCF, 0xBE, 0x7D, 0xE3, 0xEF,
  0x1E, 0x79, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0x78, 0x00, 0x03, 0xC0,
  0xFF, 0x1F, 0xE3, 0xFE, 0x3E, 0x47, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x88, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0xE7, 0x83, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1E,
  0x1E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03,
  0xDE, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xF3, 0xC7, 0xBE, 0x7D,
  0xFF, 0xCF, 0xFE, 0x7F, 0xC3, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xCC, 0x3F,
  0xE0, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xA0,
  0x1E, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F,
  0xBC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3C, 0x78, 0x78, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xC3, 0x0F, 0x87, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x30, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xF7, 0xCF, 0xBE, 0x79,
  0xF7, 0xCF, 0xBE, 0x79, 0xF3, 0xCF, 0x1E, 0x79, 0xF7, 0xCF, 0xBE, 0x79,
  0xE3, 0xCF, 0x3E, 0x00, 0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x47, 0x8F, 0x0F,
  0x3E, 0x3E, 0xF8, 0x7F, 0xE0, 0xF7, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xC3, 0xE7, 0xC7, 0x8F, 0x8F,
  0x1F, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E,
  0x0F, 0x00, 0x02, 0x61, 0xC1, 0xDF, 0xBE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3E, 0xFD, 0xF3, 0xEF, 0x9F, 0x3C, 0xF9, 0xE7, 0xCF, 0x9E, 0x7C, 0xF1,
  0xE7, 0xCF, 0x3E, 0x79, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9, 0xF3, 0xCF, 0x9E,
  0x7C, 0xF1, 0xE7, 0xCF, 0x3E, 0x7C, 0x00, 0x60, 0xFF, 0xC7, 0xFE, 0x7F,
  0xF3, 0xEF, 0x9F, 0x3C, 0xF3, 0xEF, 0x9F, 0x7C, 0xF3, 0xE7, 0x9E, 0x3C,
  0xF3, 0xEF, 0x9F, 0x7C, 0xF3, 0xC7, 0x9E, 0x7C, 0x03, 0xC0, 0x7F, 0x07,
  0xFC, 0x3F, 0xF3, 0xEF, 0x9E, 0x7D, 0xF3, 0xEF, 0x1F, 0x78, 0xFB, 0xC7,
  0xBE, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x00, 0x18,
  0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0xF3, 0xE3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1E, 0xF0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x3E, 0xF1, 0xFF, 0xCF,
  0xFE, 0x3E, 0xF8, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xCF,
  0x9F, 0x3E, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x63, 0xBC, 0x77, 0x9F, 0xE3, 0xFC, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x07, 0x03, 0xFC,
  0xFF, 0x9F, 0xE3, 0xC4, 0x78, 0x0F, 0x81, 0xFC, 0x1F, 0x81, 0xF0, 0x1F,
  0x43, 0xEF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF0, 0x0F, 0x03, 0x81, 0xE0, 0x79,
  0x7F, 0x9F, 0xEF, 0xF8, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x83, 0xF8, 0xFE, 0x3F, 0x87, 0xE0, 0x3C, 0xFB, 0xE7, 0xDF, 0x3E,
  0xF9, 0xE7, 0x8F, 0x3C, 0xFB, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE1, 0xEF, 0x00, 0xF1, 0xFF, 0x1E, 0xF3,
  0xEF, 0x3E, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x79, 0xF9, 0xF7, 0x9F, 0xBE,
  0x7B, 0xF3, 0xC7, 0xBF, 0x3C, 0x7B, 0xF7, 0xC7, 0xFF, 0x78, 0x7F, 0x77,
  0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xEF, 0xF0, 0x7E, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x00, 0x1F, 0x3E, 0x3E,
  0xF8, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDF, 0x1F, 0x3E, 0x3E,
  0x7C, 0x00, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x5F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF8,
  0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0x80, 0x10, 0x0B, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x40, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 20, 7, 0, -20 },
  { 24, 11, 7, 13, 3, -20 },
  { 34, 16, 20, 15, 0, -20 },
  { 74, 14, 23, 13, 0, -21 },
  { 115, 20, 20, 22, 2, -20 },
  { 165, 17, 20, 17, 0, -20 },
  { 208, 5, 7, 7, 3, -20 },
  { 213, 10, 25, 8, 0, -21 },
  { 245, 10, 25, 8, -2, -21 },
  { 277, 12, 14, 12, 2, -22 },
  { 298, 12, 14, 14, 1, -17 },
  { 319, 7, 8, 7, -2, -4 },
  { 326, 8, 5, 9, 0, -10 },
  { 331, 5, 5, 7, 0, -5 },
  { 335, 16, 20, 11, -2, -20 },
  { 375, 12, 20, 13, 1, -20 },
  { 405, 11, 20, 13, 2, -20 },
  { 433, 14, 20, 13, -1, -20 },
  { 468, 13, 20, 13, 0, -20 },
  { 501, 14, 20, 13, 0, -20 },
  { 536, 13, 20, 13, 1, -20 },
  { 569, 13, 20, 13, 1, -20 },
  { 602, 14, 20, 13, 1, -20 },
  { 637, 14, 20, 13, 0, -20 },
  { 672, 13, 20, 13, 0, -20 },
  { 705, 7, 16, 7, 0, -16 },
  { 719, 9, 20, 7, -2, -16 },
  { 742, 12, 14, 14, 1, -17 },
  { 763, 12, 10, 14, 1, -15 },
  { 778, 12, 14, 14, 1, -17 },
  { 799, 11, 20, 11, 1, -20 },
  { 827, 19, 22, 20, 1, -20 },
  { 880, 15, 20, 15, -2, -20 },
  { 918, 15, 20, 14, 0, -20 },
  { 956, 14, 20, 13, 1, -20 },
  { 991, 15, 20, 15, 0, -20 },
  { 1029, 13, 20, 12, 0, -20 },
  { 1062, 13, 20, 11, 0, -20 },
  { 1095, 15, 20, 15, 1, -20 },
  { 1133, 17, 20, 16, 0, -20 },
  { 1176, 14, 20, 10, -1, -20 },
  { 1211, 13, 26, 8, -4, -20 },
  { 1254, 17, 20, 14, 0, -20 },
  { 1297, 10, 20, 11, 0, -20 },
  { 1322, 22, 20, 21, 0, -20 },
  { 1377, 18, 20, 17, 0, -20 },
  { 1422, 15, 20, 16, 1, -20 },
  { 1460, 14, 20, 14, 0, -20 },
  { 1495, 15, 25, 16, 1, -20 },
  { 1542, 15, 20, 14, 0, -20 },
  { 1580, 15, 20, 12, -1, -20 },
  { 1618, 12, 20, 12, 2, -20 },
  { 1648, 15, 20, 15, 1, -20 },
  { 1686, 14, 20, 15, 3, -20 },
  { 1721, 21, 20, 21, 2, -20 },
  { 1774, 18, 20, 14, -2, -20 },
  { 1819, 13, 20, 14, 3, -20 },
  { 1852, 15, 20, 12, -1, -20 },
  { 1890, 11, 26, 8, -1, -21 },
  { 1926, 6, 20, 11, 3, -20 },
  { 1941, 12, 26, 8, -2, -21 },
  { 1980, 14, 13, 13, -1, -20 },
  { 2003, 12, 3, 11, -3, 2 },
  { 2008, 6, 4, 9, 4, -21 },
  { 2011, 14, 16, 14, 0, -16 },
  { 2039, 13, 21, 14, 0, -21 },
  { 2074, 12, 16, 11, 0, -16 },
  { 2098, 15, 21, 14, 0, -21 },
  { 2138, 13, 16, 13, 0, -16 },
  { 2164, 15, 28, 9, -3, -21 },
  { 2217, 15, 23, 14, -1, -16 },
  { 2261, 13, 21, 14, 0, -21 },
  { 2296, 8, 22, 7, 0, -22 },
  { 2318, 12, 29, 7, -4, -22 },
  { 2362, 15, 21, 14, 0, -21 },
  { 2402, 9, 21, 7, 0, -21 },
  { 2426, 20, 16, 20, 0, -16 },
  { 2466, 13, 16, 14, 0, -16 },
  { 2492, 13, 16, 13, 0, -16 },
  { 2518, 15, 23, 14, -2, -16 },
  { 2562, 14, 23, 14, 0, -16 },
  { 2603, 11, 16, 10, 0, -16 },
  { 2625, 11, 16, 11, 0, -16 },
  { 2647, 10, 19, 10, 1, -19 },
  { 2671, 13, 15, 14, 1, -15 },
  { 2696, 12, 15, 13, 2, -15 },
  { 2719, 20, 15, 19, 1, -15 },
  { 2757, 15, 15, 13, -1, -15 },
  { 2786, 16, 22, 13, -2, -15 },
  { 2830, 13, 15, 11, -1, -15 },
  { 2855, 12, 24, 10, 0, -20 },
  { 2891, 4, 28, 11, 3, -22 },
  { 2905, 12, 24, 10, -2, -20 },
  { 2941, 13, 6, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC28PT7B_H_
