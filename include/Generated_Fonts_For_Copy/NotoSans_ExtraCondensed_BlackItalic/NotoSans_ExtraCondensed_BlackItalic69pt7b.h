#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0xE3, 0xE0, 0x07, 0xFC, 0xF0, 0x70, 0x03, 0xFE, 0x78, 0x10, 0x01, 0xFF,
  0x38, 0x00, 0x00, 0xFF, 0x9C, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xEF, 0xFC,
  0x04, 0x00, 0xF7, 0xFE, 0x03, 0x00, 0x73, 0xFF, 0x01, 0xE0, 0x39, 0xFF,
  0x80, 0xF8, 0x1C, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF,
  0xEF, 0xFF, 0xE3, 0xFE, 0x7F, 0xDF, 0xF3, 0xFF, 0xE3, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0xC1, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0x81, 0xFF, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x01, 0xFF, 0x00, 0x18,
  0x1F, 0xF0, 0x03, 0xE1, 0xFE, 0x00, 0x3F, 0x1F, 0xE0, 0x27, 0xFD, 0xFE,
  0x1E, 0x7F, 0xFF, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x80, 0xFC, 0x1F, 0xF0, 0x07, 0xC1, 0xFC, 0x00, 0x38, 0x0F, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF,
  0x3F, 0xF0, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0,
  0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFE,
  0x07, 0xF9, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x0F, 0x8F, 0xFF, 0x00, 0xE1,
  0xFF, 0xC0, 0x08, 0x3F, 0xF8, 0x01, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x3F, 0xFC,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x7F,
  0xF0, 0x00, 0xC0, 0x3F, 0xFC, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFF, 0xE0, 0x07, 0x00, 0xFF, 0xF0,
  0x02, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x84, 0x00, 0x07, 0xFF, 0xC3, 0x00,
  0x03, 0xFF, 0xC1, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0x9F, 0xFC, 0x00, 0x1F,
  0xE7, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xE0, 0x03,
  0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xE2, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFD, 0xFF,
  0xFE, 0x00, 0x20, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x08, 0x00, 0x1F, 0xFF, 0x06, 0x00, 0x0F, 0xFF, 0x03, 0xC0,
  0x0F, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0x7F, 0xF0, 0x00, 0x30, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0x83, 0x80, 0x7F, 0xF0,
  0x60, 0x0F, 0xFE, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x02, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0x80, 0xFF,
  0x03, 0xFF, 0xFE, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0x83,
  0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x7F, 0x87, 0xF8,
  0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF9, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xCF, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0x9F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x3F, 0x87, 0xF8, 0x1F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF1, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFC,
  0x7F, 0x87, 0xF0, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xEF, 0xFF,
  0xC0, 0x7F, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xDF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x03,
  0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xF8, 0x01, 0xFF,
  0xF8, 0x06, 0x00, 0x3F, 0xFE, 0x00, 0x40, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x20,
  0x03, 0xFF, 0xE0, 0x1C, 0x00, 0x7F, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x10, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x70, 0x03, 0xFF, 0xF0, 0x00, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x7F,
  0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x80,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF3, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xDF, 0xFB,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x7F, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFD,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFE,
  0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0xFF, 0xE0, 0x07,
  0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x9F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x07,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F,
  0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F,
  0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F,
  0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0x00, 0x1F, 0xFE, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x08, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x02,
  0x00, 0x0F, 0xFF, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xFC,
  0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3D, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x3F,
  0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xFF,
  0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xDF, 0xF7, 0xFF, 0x00, 0x3F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x7F, 0xDF, 0xFC, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x40, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xE7, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFB, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x0F, 0xFE, 0x7F, 0xC0,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xC0,
  0x1F, 0xF3, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xE0, 0x3F, 0xFC,
  0x02, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x08, 0x0F,
  0xFF, 0x01, 0xC0, 0x7F, 0xFC, 0x3E, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFB,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x7F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xFE, 0x00, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x1F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x83, 0xFF, 0xC0, 0x0E, 0x07, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFE,
  0x7F, 0xE0, 0x03, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xE0, 0x00, 0x0E, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x7C,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x3C, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF,
  0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x87, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xBF,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x01, 0xFF,
  0xBF, 0xFF, 0xBF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF,
  0xBF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xF0,
  0x00, 0x3F, 0xE7, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFF,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x03, 0xFF,
  0x81, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF,
  0x1F, 0xFC, 0x00, 0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE3, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xF8,
  0x0F, 0xFE, 0x03, 0x00, 0xFF, 0xE0, 0x10, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x08,
  0x00, 0xFF, 0xF0, 0xC0, 0x0F, 0xFF, 0x0F, 0x81, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x08, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF,
  0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF,
  0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x7F, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF,
  0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF,
  0xFC, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF,
  0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF,
  0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xF7, 0xF9, 0xFF, 0x80, 0x7F, 0xEF, 0xF7,
  0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xE7,
  0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0xFF, 0xF0, 0x00,
  0x17, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xA0, 0x00,
  0x7F, 0xFC, 0x80, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 22, 50, 18, 0, -49 },
  { 139, 29, 18, 31, 6, -49 },
  { 205, 39, 49, 36, 0, -49 },
  { 444, 33, 56, 33, 1, -52 },
  { 675, 49, 51, 55, 4, -50 },
  { 988, 42, 51, 41, 0, -50 },
  { 1256, 15, 18, 17, 6, -49 },
  { 1290, 24, 62, 19, 1, -51 },
  { 1476, 25, 62, 19, -6, -51 },
  { 1670, 28, 32, 31, 5, -53 },
  { 1782, 30, 33, 35, 3, -41 },
  { 1906, 17, 20, 18, -4, -10 },
  { 1949, 19, 11, 21, 1, -24 },
  { 1976, 13, 13, 18, 0, -12 },
  { 1998, 38, 51, 27, -4, -50 },
  { 2241, 31, 51, 33, 2, -50 },
  { 2439, 27, 49, 33, 6, -49 },
  { 2605, 34, 50, 33, -2, -50 },
  { 2818, 33, 51, 33, 0, -50 },
  { 3029, 34, 49, 33, -1, -49 },
  { 3238, 33, 50, 33, 1, -49 },
  { 3445, 33, 51, 33, 2, -50 },
  { 3656, 34, 49, 33, 2, -49 },
  { 3865, 33, 51, 33, 1, -50 },
  { 4076, 32, 51, 33, 1, -50 },
  { 4280, 18, 40, 18, 0, -39 },
  { 4370, 22, 49, 18, -4, -39 },
  { 4505, 30, 34, 35, 3, -42 },
  { 4633, 30, 25, 35, 3, -37 },
  { 4727, 30, 34, 35, 3, -42 },
  { 4855, 27, 51, 26, 2, -50 },
  { 5028, 47, 55, 49, 2, -50 },
  { 5352, 37, 49, 37, -4, -49 },
  { 5579, 37, 49, 36, 0, -49 },
  { 5806, 35, 51, 33, 2, -50 },
  { 6030, 38, 49, 37, 0, -49 },
  { 6263, 32, 49, 29, 0, -49 },
  { 6459, 32, 49, 28, 0, -49 },
  { 6655, 38, 51, 38, 2, -50 },
  { 6898, 42, 49, 39, 0, -49 },
  { 7156, 34, 49, 26, -3, -49 },
  { 7365, 33, 64, 19, -11, -49 },
  { 7629, 42, 49, 35, 0, -49 },
  { 7887, 25, 49, 28, 0, -49 },
  { 8041, 54, 49, 51, 0, -49 },
  { 8372, 45, 49, 42, 0, -49 },
  { 8648, 38, 51, 40, 2, -50 },
  { 8891, 35, 49, 33, 0, -49 },
  { 9106, 38, 62, 40, 2, -50 },
  { 9401, 36, 49, 35, 0, -49 },
  { 9622, 35, 51, 30, -1, -50 },
  { 9846, 30, 49, 30, 5, -49 },
  { 10030, 39, 50, 38, 2, -49 },
  { 10274, 36, 49, 36, 6, -49 },
  { 10495, 53, 49, 51, 5, -49 },
  { 10820, 44, 49, 35, -4, -49 },
  { 11090, 34, 49, 34, 6, -49 },
  { 11299, 38, 49, 30, -3, -49 },
  { 11532, 28, 63, 20, -3, -51 },
  { 11753, 16, 51, 27, 7, -50 },
  { 11855, 29, 63, 20, -5, -51 },
  { 12084, 33, 32, 32, -1, -49 },
  { 12216, 29, 9, 27, -7, 4 },
  { 12249, 15, 11, 23, 10, -53 },
  { 12270, 34, 40, 34, 1, -39 },
  { 12440, 34, 53, 34, -1, -52 },
  { 12666, 29, 40, 27, 1, -39 },
  { 12811, 37, 53, 34, 1, -52 },
  { 13057, 30, 40, 32, 1, -39 },
  { 13207, 37, 70, 21, -8, -53 },
  { 13531, 37, 56, 34, -2, -39 },
  { 13790, 34, 52, 34, -1, -52 },
  { 14011, 22, 54, 17, -1, -54 },
  { 14160, 30, 71, 17, -9, -54 },
  { 14427, 38, 52, 33, -1, -52 },
  { 14674, 22, 52, 17, -1, -52 },
  { 14817, 50, 39, 50, -1, -39 },
  { 15061, 34, 39, 34, -1, -39 },
  { 15227, 31, 40, 33, 1, -39 },
  { 15382, 37, 56, 34, -4, -39 },
  { 15641, 34, 56, 34, 1, -39 },
  { 15879, 29, 39, 24, -1, -39 },
  { 16021, 28, 40, 27, 0, -39 },
  { 16161, 23, 47, 24, 3, -46 },
  { 16297, 34, 39, 34, 1, -38 },
  { 16463, 31, 38, 32, 4, -38 },
  { 16611, 48, 38, 47, 3, -38 },
  { 16839, 39, 38, 32, -4, -38 },
  { 17025, 39, 55, 32, -4, -38 },
  { 17294, 32, 38, 27, -3, -38 },
  { 17446, 29, 60, 24, 0, -49 },
  { 17664, 9, 69, 27, 9, -53 },
  { 17742, 27, 60, 24, -4, -49 },
  { 17945, 30, 13, 35, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC69PT7B_H_
