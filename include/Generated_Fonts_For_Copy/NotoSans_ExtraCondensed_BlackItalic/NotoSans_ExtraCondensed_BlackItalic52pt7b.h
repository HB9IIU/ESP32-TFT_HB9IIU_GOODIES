#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0x10, 0x00, 0x3F, 0xEF, 0xFB, 0xFE, 0x7F, 0xDF, 0xF3,
  0xFE, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF,
  0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFD, 0xDF, 0x01, 0xFC, 0xE3, 0x80, 0xFE, 0x60, 0x80,
  0x7F, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x10, 0x0C, 0xFE, 0x0C, 0x0E, 0x7F, 0x07, 0x87,
  0x7F, 0x03, 0xF3, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0xFE,
  0xFC, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x7E, 0x3F, 0x87, 0xF0,
  0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xCF, 0xE0, 0xF0, 0xFC, 0xFE, 0x7E,
  0x3F, 0xE7, 0xE7, 0xE7, 0xF3, 0xFF, 0xBF, 0xFF, 0x3F, 0x3F, 0xFD, 0xFF,
  0xF3, 0xF9, 0xFF, 0xF7, 0xFF, 0x1F, 0x9F, 0xFF, 0xBF, 0xF9, 0xF9, 0xFC,
  0xFC, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xC0, 0xFC, 0x7E, 0x3F, 0x00, 0x0F,
  0xE7, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0x7E, 0x3F, 0x00, 0x1F, 0x83,
  0xF1, 0xF8, 0x01, 0xF8, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0, 0xFC, 0xFC, 0x00,
  0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFE, 0x00, 0x7E, 0x01, 0xFF,
  0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE3,
  0xFC, 0x07, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0x7F,
  0xC3, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xCF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0x87,
  0xFC, 0x3F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xF7, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F,
  0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x10, 0x7F, 0x00, 0x61,
  0xF8, 0x03, 0xE7, 0xE0, 0x8F, 0xFF, 0x9F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFD,
  0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0x8F, 0xF0, 0x1C, 0x3F, 0x00, 0x30, 0x70,
  0x00, 0x81, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFB, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE,
  0x1F, 0xE7, 0xF8, 0x7F, 0xCF, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xC3,
  0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F,
  0xDF, 0xF0, 0xFF, 0xBF, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF9,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F,
  0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0x7F, 0x87, 0xEF, 0xF8, 0x3C, 0xFF, 0x83, 0x8F, 0xF0, 0x10, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0x80, 0xF8, 0x7F, 0xC0, 0x38, 0x1F,
  0xE0, 0x18, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xE0, 0xFF, 0x80, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x88, 0x00, 0xFF, 0xC4, 0x00, 0x7F, 0xC3, 0xC0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xEF, 0xF0, 0x07, 0xE7, 0xF8, 0x03, 0xF7, 0xFC, 0x03, 0xF3, 0xFE, 0x03,
  0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xF8, 0xFF, 0x81, 0xF8, 0x7F, 0xC1,
  0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x06,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x80, 0x1F, 0xF8, 0xC0,
  0x1F, 0xF0, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0x80, 0x3F,
  0xCF, 0xE0, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xF8, 0xFF,
  0x87, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0xBF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F,
  0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F,
  0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xE7, 0xF8, 0x01, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x80,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E, 0x1F, 0xF1,
  0x80, 0xFF, 0x10, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E,
  0x07, 0xF0, 0x7F, 0xC3, 0xF0, 0x7E, 0x1F, 0xFF, 0x3F, 0x0F, 0xC3, 0xFF,
  0xF3, 0xF0, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0x8F, 0xFF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x87, 0xE3, 0xF3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x3E, 0x3F, 0x0F, 0xC3, 0xE7, 0xE3, 0xF0, 0xFC, 0x3E, 0x7E, 0x3F, 0x0F,
  0xC3, 0xE7, 0xC7, 0xE0, 0xFC, 0x7E, 0x7C, 0x7E, 0x1F, 0x87, 0xCF, 0xC7,
  0xE1, 0xF8, 0x7C, 0xFC, 0x7E, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF8, 0xF8,
  0xFC, 0x7E, 0x3F, 0x9F, 0x8F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF,
  0xFE, 0x0F, 0xC3, 0xFE, 0xFF, 0xC0, 0xFC, 0x3F, 0xC7, 0xF8, 0x0F, 0xC0,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F,
  0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC3, 0xFF, 0x07, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0x1C, 0x03, 0xFF, 0x01, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x10, 0x0F, 0xFC, 0x3C,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x83, 0xFC, 0x3F, 0xF0, 0x3F, 0xC7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0x07, 0x80, 0xFF, 0xE0, 0x08, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F, 0xFC, 0x7F, 0xC7,
  0xFF, 0x87, 0xFC, 0x7F, 0xF8, 0xFF, 0x87, 0xFF, 0x8F, 0xF8, 0x7F, 0xF8,
  0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x43, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03,
  0xFC, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFF,
  0xF3, 0xFB, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0xFD, 0xFD,
  0xFE, 0x01, 0xFE, 0xFE, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0x7F, 0x80,
  0x7F, 0xBF, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF,
  0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xFF, 0xCF, 0xF0, 0x0F, 0xF3, 0xFF, 0xC7,
  0xF8, 0x07, 0xF9, 0xFF, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0xE3, 0xFE, 0x03,
  0xFE, 0x7F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0x00, 0xFF, 0x1F,
  0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xC0,
  0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xF1, 0xFE,
  0x01, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0xBF, 0xC0, 0x7F, 0x9F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xF8, 0x07, 0xF9,
  0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0xE0, 0x3F,
  0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0x00,
  0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xF8,
  0x07, 0xF8, 0x1F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x81, 0xFF,
  0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF7, 0xFF, 0x03, 0xFC, 0x7F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC,
  0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xE3, 0xFE,
  0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x3F,
  0x01, 0xFF, 0x81, 0x80, 0x7F, 0xC0, 0x20, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x80,
  0x1F, 0xF0, 0x30, 0x0F, 0xFC, 0x1F, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F,
  0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x9F, 0xE0, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC7, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x87, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF1,
  0xFF, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0xF1,
  0xFF, 0x03, 0xFC, 0x7F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFC, 0xFF, 0x80,
  0xFF, 0x3F, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF,
  0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xFF, 0xDF, 0xE0, 0x0F, 0xF7, 0xFF, 0xEF,
  0xF0, 0x07, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x01,
  0xFF, 0xFD, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F,
  0xF3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFF, 0x3F, 0xC1, 0xFF, 0xDF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F,
  0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFB,
  0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7,
  0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xDF, 0xFC, 0x07, 0xF3, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFE, 0x18, 0x3F, 0xE0,
  0x41, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x10, 0x7F, 0xC1, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x3F,
  0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x8F,
  0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFF, 0x0F, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x08, 0x3F, 0xF0, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFE, 0x0F,
  0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x02, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x0F, 0xF0, 0x18,
  0x03, 0xFE, 0x03, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83,
  0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xCF,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0xFE, 0x07, 0xE0, 0x0F, 0xE7, 0xFC, 0x7F, 0xC0, 0x3F, 0xBF, 0xFB, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xFB, 0xFF,
  0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC1,
  0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x3F,
  0xBF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x1F,
  0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xF9, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFE,
  0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE7,
  0xFC, 0x00, 0xFE, 0xFF, 0xC0, 0x0F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xF0, 0x03,
  0xFC, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0xBF,
  0xC0, 0xFF, 0xDF, 0xE0, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xF9, 0xFE,
  0x00, 0x20, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x18, 0x1F, 0xE0, 0x40, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x88, 0x07, 0xFC, 0x70, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x20, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFD, 0xFC, 0x0F, 0xFC, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83,
  0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F,
  0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x7F,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0x7F, 0x87, 0xFE, 0x1F, 0xEF, 0xF1, 0xFF,
  0xC7, 0xF9, 0xFE, 0x3F, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0x3F, 0xE7, 0xF9,
  0xFF, 0xE7, 0xF8, 0xFF, 0x3F, 0xFC, 0xFF, 0x1F, 0xEF, 0xFF, 0xBF, 0xC3,
  0xFD, 0xFF, 0xF7, 0xF8, 0x7F, 0xBF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFB, 0xF7, 0xF8, 0x3F, 0xBF, 0x7E, 0xFE, 0x07, 0xFF, 0xEF,
  0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF,
  0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x01,
  0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x0F, 0xF9, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 38, 13, 0, -37 },
  { 77, 21, 13, 23, 5, -37 },
  { 112, 29, 37, 27, 0, -37 },
  { 247, 25, 42, 25, 1, -39 },
  { 379, 37, 38, 41, 3, -38 },
  { 555, 31, 39, 31, 0, -38 },
  { 707, 11, 13, 13, 5, -37 },
  { 725, 18, 46, 15, 1, -38 },
  { 829, 18, 46, 15, -4, -38 },
  { 933, 22, 24, 23, 3, -40 },
  { 999, 23, 25, 26, 2, -31 },
  { 1071, 13, 15, 14, -3, -8 },
  { 1096, 15, 8, 16, 0, -18 },
  { 1111, 9, 10, 14, 0, -9 },
  { 1123, 28, 39, 21, -3, -38 },
  { 1260, 23, 39, 25, 2, -38 },
  { 1373, 20, 37, 25, 5, -37 },
  { 1466, 25, 38, 25, -1, -38 },
  { 1585, 25, 39, 25, 0, -38 },
  { 1707, 25, 37, 25, 0, -37 },
  { 1823, 24, 38, 25, 1, -37 },
  { 1937, 24, 39, 25, 2, -38 },
  { 2054, 26, 37, 25, 1, -37 },
  { 2175, 25, 39, 25, 0, -38 },
  { 2297, 24, 39, 25, 1, -38 },
  { 2414, 14, 30, 14, 0, -29 },
  { 2467, 17, 36, 14, -3, -29 },
  { 2544, 23, 26, 26, 2, -32 },
  { 2619, 23, 19, 26, 2, -28 },
  { 2674, 23, 26, 26, 2, -32 },
  { 2749, 20, 39, 20, 2, -38 },
  { 2847, 36, 42, 37, 1, -38 },
  { 3036, 28, 37, 28, -3, -37 },
  { 3166, 28, 37, 27, 0, -37 },
  { 3296, 26, 39, 24, 2, -38 },
  { 3423, 28, 37, 28, 0, -37 },
  { 3553, 24, 37, 22, 0, -37 },
  { 3664, 24, 37, 21, 0, -37 },
  { 3775, 28, 39, 29, 2, -38 },
  { 3912, 31, 37, 29, 0, -37 },
  { 4056, 25, 37, 19, -2, -37 },
  { 4172, 24, 49, 14, -8, -37 },
  { 4319, 32, 37, 27, 0, -37 },
  { 4467, 19, 37, 21, 0, -37 },
  { 4555, 41, 37, 39, 0, -37 },
  { 4745, 34, 37, 31, 0, -37 },
  { 4903, 28, 39, 30, 2, -38 },
  { 5040, 27, 37, 25, 0, -37 },
  { 5165, 28, 47, 30, 2, -38 },
  { 5330, 27, 37, 26, 0, -37 },
  { 5455, 26, 39, 23, -1, -38 },
  { 5582, 22, 37, 22, 4, -37 },
  { 5684, 29, 38, 28, 2, -37 },
  { 5822, 27, 37, 27, 5, -37 },
  { 5947, 41, 37, 39, 3, -37 },
  { 6137, 33, 37, 26, -3, -37 },
  { 6290, 25, 37, 25, 5, -37 },
  { 6406, 28, 37, 23, -2, -37 },
  { 6536, 22, 47, 15, -3, -38 },
  { 6666, 12, 39, 21, 5, -38 },
  { 6725, 22, 47, 15, -4, -38 },
  { 6855, 25, 24, 24, -1, -37 },
  { 6930, 21, 7, 20, -5, 3 },
  { 6949, 12, 8, 17, 7, -40 },
  { 6961, 25, 30, 25, 1, -29 },
  { 7055, 26, 41, 25, -1, -40 },
  { 7189, 21, 30, 21, 1, -29 },
  { 7268, 27, 41, 25, 1, -40 },
  { 7407, 23, 30, 24, 1, -29 },
  { 7494, 28, 52, 16, -6, -40 },
  { 7676, 27, 41, 25, -1, -29 },
  { 7815, 26, 40, 26, -1, -40 },
  { 7945, 17, 40, 13, -1, -40 },
  { 8030, 23, 52, 13, -7, -40 },
  { 8180, 29, 40, 25, -1, -40 },
  { 8325, 17, 40, 13, -1, -40 },
  { 8410, 38, 29, 38, -1, -29 },
  { 8548, 26, 29, 26, -1, -29 },
  { 8643, 23, 30, 25, 1, -29 },
  { 8730, 28, 41, 25, -3, -29 },
  { 8874, 25, 41, 25, 1, -29 },
  { 9003, 22, 29, 18, -1, -29 },
  { 9083, 21, 30, 20, 0, -29 },
  { 9162, 18, 36, 18, 2, -35 },
  { 9243, 25, 30, 26, 1, -29 },
  { 9337, 24, 29, 24, 3, -29 },
  { 9424, 35, 29, 35, 3, -29 },
  { 9551, 29, 29, 24, -3, -29 },
  { 9657, 30, 41, 24, -3, -29 },
  { 9811, 24, 29, 20, -2, -29 },
  { 9898, 22, 45, 18, 0, -37 },
  { 10022, 8, 52, 20, 6, -40 },
  { 10074, 21, 45, 18, -3, -37 },
  { 10193, 23, 10, 26, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC52PT7B_H_
