#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xC0,
  0x00, 0x3F, 0xDF, 0xE7, 0xF3, 0xFC, 0xFE, 0x7F, 0xBF, 0xCF, 0xE7, 0xF9,
  0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF9, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xF3, 0xF8, 0xFC, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC7,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFD, 0xC6,
  0x07, 0xF6, 0x08, 0x1F, 0xD8, 0x00, 0x7F, 0x60, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1B, 0xF0,
  0x40, 0xEF, 0xC1, 0xC3, 0x3F, 0x07, 0xCD, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7E,
  0x7C, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0xFC,
  0x7C, 0x3E, 0x00, 0xFC, 0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x7C, 0x00, 0xF8,
  0xFC, 0xFC, 0x00, 0xF8, 0xF9, 0xF8, 0x00, 0xF9, 0xF9, 0xF8, 0xFC, 0xF9,
  0xFB, 0xF3, 0xFE, 0xFF, 0xF3, 0xE7, 0xFF, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF,
  0xE7, 0xCF, 0xFF, 0x7F, 0xCF, 0xDF, 0x9F, 0x3F, 0x1F, 0x9F, 0x9F, 0x00,
  0x1F, 0x9F, 0x1F, 0x00, 0x3F, 0x3F, 0x1F, 0x00, 0x3E, 0x3F, 0x1F, 0x00,
  0x7E, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x3F, 0x00,
  0xF8, 0x3E, 0x3E, 0x01, 0xF8, 0x3E, 0x7E, 0x03, 0xF0, 0x3F, 0xFC, 0x03,
  0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x10, 0x3F, 0xF8, 0xFE, 0x07,
  0xFF, 0x9F, 0xE0, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xBF, 0xFF, 0x87, 0xF9, 0xFF, 0xF0, 0x7F, 0x1F, 0xFF, 0x0F,
  0xF1, 0xFF, 0xE0, 0xFF, 0x0F, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x10, 0x7E, 0x03, 0x8F, 0x80, 0x79, 0xF0,
  0xDF, 0xFE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0x3F, 0x03, 0xE7, 0xF0, 0x38, 0xFC, 0x02, 0x0E, 0x00, 0x01, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xCF, 0xFF, 0x00, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x7F, 0x9F,
  0xC3, 0xFC, 0xFE, 0x1F, 0xEF, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC,
  0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFB, 0xF8, 0x7C, 0xFE, 0x0E, 0x7F, 0x81,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFE, 0xFF, 0x80, 0xF0, 0xFF, 0x01, 0xC1, 0xFE, 0x01, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E,
  0x7F, 0xC0, 0x40, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0x3F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE2, 0x00, 0xFF, 0x8F, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7D, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xBF, 0x80, 0x7E, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0x9F, 0xE0,
  0x7E, 0x7F, 0x83, 0xF1, 0xFC, 0x0F, 0x87, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFB, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x83, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x80, 0x3F, 0xC2, 0x01, 0xFF, 0x0F, 0x0F, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF3, 0xE0,
  0x3F, 0xDF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE1,
  0xFC, 0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF,
  0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE3, 0xFC,
  0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x8F, 0xF3,
  0xFC, 0x7F, 0x9F, 0xC3, 0xFC, 0xFF, 0x3F, 0xC7, 0xFB, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x07,
  0xCF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x20, 0x7F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xF0, 0x7F, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00,
  0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xF3, 0xFC, 0x70, 0x7F, 0x10, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3E, 0x07, 0xC1, 0xFC, 0x3E, 0x0F, 0xC7, 0xFF, 0xBE, 0x1F, 0x8F, 0xFF,
  0x1F, 0x1F, 0x1F, 0xFF, 0x1F, 0x3F, 0x1F, 0x9F, 0x1F, 0x3E, 0x3F, 0x1F,
  0x1E, 0x3E, 0x3E, 0x3F, 0x3E, 0x7C, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E,
  0x3E, 0x7C, 0xFC, 0x3E, 0x3E, 0x7C, 0xF8, 0x7E, 0x3C, 0xF8, 0xF8, 0x7C,
  0x7C, 0xF8, 0xF8, 0x7C, 0x7C, 0xF8, 0xF8, 0xFC, 0x78, 0xF8, 0xF8, 0xFC,
  0xF8, 0xF8, 0xFF, 0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0xBF,
  0xE0, 0xF8, 0x7F, 0x3F, 0xC0, 0xF8, 0x1C, 0x0F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xFB,
  0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xF9,
  0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xBF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xF8, 0x10, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x02, 0x03, 0xFE, 0x3C, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xFC, 0x3F, 0xC7, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFB, 0xF0, 0x1F,
  0xF0, 0x18, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xF9,
  0xFF, 0x3F, 0xF8, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xFE, 0x3F, 0xC7, 0xFF,
  0x1F, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x4F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC,
  0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xDF,
  0xBF, 0xFF, 0x81, 0xFD, 0xFB, 0xF7, 0xF0, 0x1F, 0xDF, 0xBF, 0x7F, 0x01,
  0xFD, 0xFF, 0xEF, 0xF0, 0x3F, 0xDF, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0xCF,
  0xE0, 0x3F, 0x9F, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F,
  0xF9, 0xFE, 0x07, 0xF9, 0xFF, 0x9F, 0xE0, 0x7F, 0x1F, 0xF1, 0xFC, 0x07,
  0xF1, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xF0, 0x3F, 0x80, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xFC,
  0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0x87,
  0xF0, 0x1F, 0xFE, 0x3F, 0xC0, 0x7F, 0xF8, 0xFF, 0x03, 0xFF, 0xE3, 0xF8,
  0x0F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0x3F, 0x80, 0xFF, 0xFD, 0xFE, 0x07,
  0xF7, 0xF7, 0xF0, 0x1F, 0xDF, 0xDF, 0xC0, 0x7F, 0x7F, 0x7F, 0x01, 0xFC,
  0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0x80, 0xFE, 0x3F,
  0xFE, 0x03, 0xF8, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0xE0, 0x3F, 0x87, 0xFF,
  0x81, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x7F, 0xF0, 0x1F, 0xC1, 0xFF, 0xC0,
  0x7F, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFD, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0x1F, 0xF0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07,
  0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F, 0xE7,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x38, 0x07, 0xF8, 0x10, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x40, 0x1F, 0xE0, 0x20, 0x1F, 0xE0, 0x78, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xF8, 0x0F,
  0xF7, 0xF8, 0x1F, 0x81, 0xFE, 0x7F, 0x83, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F,
  0x81, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F,
  0x07, 0xF1, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xF8, 0xFF, 0x07, 0xF1, 0xFF,
  0x8F, 0xE0, 0x7F, 0x3F, 0xF9, 0xFE, 0x07, 0xF3, 0xFF, 0x9F, 0xC0, 0x7F,
  0x7F, 0xFB, 0xFC, 0x07, 0xF7, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0xFB, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xDF,
  0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0xFF,
  0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0,
  0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x7E, 0x07, 0xF0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x07,
  0xE7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x3F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE7,
  0xF0, 0x7F, 0xDF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xF3, 0xFE, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0x9F, 0x80, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0xE0,
  0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFC, 0xFF, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFD, 0xC1, 0xFE, 0x08, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x10, 0x7F, 0x86, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xCF, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0x80, 0x3F, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x10, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE4, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC4, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x9F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x7F, 0x03, 0xFF, 0x7E, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87,
  0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x80, 0x3F, 0xC0, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x80, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xDF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x3F, 0x87, 0xF8,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xDF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE7, 0xF8, 0xFE, 0x0F, 0xF1,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7,
  0xF8, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xDF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xEF, 0xF3,
  0xFC, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x07, 0xFC, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE,
  0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE7,
  0xF0, 0x7F, 0xDF, 0xC3, 0xFF, 0x7E, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xF3, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xBF, 0x80, 0xFD, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0x3E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xF8, 0x40,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF1, 0xC0, 0xFE,
  0x08, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE2, 0x03, 0xFC, 0x70, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x11, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8,
  0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xF9,
  0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x0F,
  0xF0, 0xFF, 0x7F, 0x1F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF1, 0xFE, 0x7F, 0x1F,
  0xF1, 0xFC, 0x7F, 0x3F, 0xF1, 0xFC, 0x7F, 0x3F, 0xF3, 0xF8, 0x7F, 0x7F,
  0xF3, 0xF8, 0x7F, 0x7F, 0xF7, 0xF8, 0x7F, 0x7F, 0xF7, 0xF0, 0x7E, 0xFF,
  0xF7, 0xF0, 0x7E, 0xFF, 0xFF, 0xE0, 0x7E, 0xFB, 0xFF, 0xE0, 0x7F, 0xFB,
  0xEF, 0xE0, 0x7F, 0xFB, 0xEF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x07,
  0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 34, 12, 0, -33 },
  { 61, 19, 12, 21, 4, -33 },
  { 90, 26, 33, 24, 0, -33 },
  { 198, 22, 38, 22, 1, -35 },
  { 303, 32, 33, 36, 3, -33 },
  { 435, 28, 33, 28, 0, -33 },
  { 551, 10, 12, 11, 4, -33 },
  { 566, 17, 41, 13, 0, -34 },
  { 654, 17, 41, 13, -4, -34 },
  { 742, 19, 21, 20, 3, -35 },
  { 792, 20, 22, 23, 2, -27 },
  { 847, 12, 13, 12, -3, -7 },
  { 867, 14, 7, 14, 0, -16 },
  { 880, 8, 9, 12, 0, -8 },
  { 889, 26, 33, 18, -3, -33 },
  { 997, 21, 33, 22, 1, -33 },
  { 1084, 18, 33, 22, 4, -33 },
  { 1159, 23, 33, 22, -1, -33 },
  { 1254, 22, 33, 22, 0, -33 },
  { 1345, 22, 33, 22, 0, -33 },
  { 1436, 22, 33, 22, 1, -33 },
  { 1527, 22, 33, 22, 1, -33 },
  { 1618, 23, 33, 22, 1, -33 },
  { 1713, 22, 33, 22, 0, -33 },
  { 1804, 21, 33, 22, 1, -33 },
  { 1891, 12, 27, 12, 0, -26 },
  { 1932, 15, 32, 12, -3, -26 },
  { 1992, 20, 23, 23, 2, -28 },
  { 2050, 20, 16, 23, 2, -24 },
  { 2090, 20, 23, 23, 2, -28 },
  { 2148, 18, 34, 17, 1, -33 },
  { 2225, 32, 36, 32, 1, -33 },
  { 2369, 25, 33, 24, -3, -33 },
  { 2473, 24, 33, 24, 0, -33 },
  { 2572, 23, 33, 22, 2, -33 },
  { 2667, 25, 33, 25, 0, -33 },
  { 2771, 22, 33, 19, 0, -33 },
  { 2862, 22, 33, 19, 0, -33 },
  { 2953, 25, 33, 25, 2, -33 },
  { 3057, 28, 33, 26, 0, -33 },
  { 3173, 23, 33, 17, -2, -33 },
  { 3268, 22, 43, 13, -7, -33 },
  { 3387, 28, 33, 24, 0, -33 },
  { 3503, 17, 33, 18, 0, -33 },
  { 3574, 36, 33, 34, 0, -33 },
  { 3723, 30, 33, 28, 0, -33 },
  { 3847, 24, 33, 26, 2, -33 },
  { 3946, 24, 33, 22, 0, -33 },
  { 4045, 24, 41, 26, 2, -33 },
  { 4168, 24, 33, 23, 0, -33 },
  { 4267, 24, 33, 20, -1, -33 },
  { 4366, 20, 33, 20, 3, -33 },
  { 4449, 25, 33, 25, 2, -33 },
  { 4553, 24, 33, 24, 4, -33 },
  { 4652, 36, 33, 34, 3, -33 },
  { 4801, 29, 33, 23, -3, -33 },
  { 4921, 23, 33, 23, 4, -33 },
  { 5016, 25, 33, 20, -2, -33 },
  { 5120, 19, 42, 13, -2, -34 },
  { 5220, 10, 33, 18, 5, -33 },
  { 5262, 20, 42, 13, -4, -34 },
  { 5367, 23, 22, 21, -1, -33 },
  { 5431, 19, 6, 18, -5, 3 },
  { 5446, 10, 7, 15, 7, -35 },
  { 5455, 22, 26, 22, 1, -26 },
  { 5527, 23, 35, 22, -1, -35 },
  { 5628, 19, 26, 18, 1, -26 },
  { 5690, 24, 35, 22, 1, -35 },
  { 5795, 20, 26, 21, 1, -26 },
  { 5860, 24, 46, 14, -5, -35 },
  { 5998, 24, 37, 22, -1, -26 },
  { 6109, 23, 35, 23, -1, -35 },
  { 6210, 15, 36, 12, -1, -36 },
  { 6278, 20, 47, 12, -6, -36 },
  { 6396, 26, 35, 22, -1, -35 },
  { 6510, 15, 35, 12, -1, -35 },
  { 6576, 34, 26, 33, -1, -26 },
  { 6687, 23, 26, 23, -1, -26 },
  { 6762, 20, 26, 22, 1, -26 },
  { 6827, 25, 37, 22, -3, -26 },
  { 6943, 22, 37, 22, 1, -26 },
  { 7045, 20, 26, 16, -1, -26 },
  { 7110, 19, 26, 18, 0, -26 },
  { 7172, 15, 31, 16, 2, -31 },
  { 7231, 22, 25, 23, 1, -25 },
  { 7300, 21, 25, 21, 3, -25 },
  { 7366, 32, 25, 31, 2, -25 },
  { 7466, 25, 25, 21, -2, -25 },
  { 7545, 27, 36, 21, -3, -25 },
  { 7667, 22, 25, 18, -2, -25 },
  { 7736, 19, 40, 16, 0, -33 },
  { 7831, 6, 46, 18, 6, -35 },
  { 7866, 19, 40, 16, -3, -33 },
  { 7961, 20, 9, 23, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC46PT7B_H_
