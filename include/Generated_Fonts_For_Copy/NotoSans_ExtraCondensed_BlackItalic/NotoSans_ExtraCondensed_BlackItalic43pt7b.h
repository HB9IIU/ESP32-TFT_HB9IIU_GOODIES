#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x7F, 0xBF, 0xDF,
  0xCF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFD, 0xBC, 0x1F, 0xB8, 0xC1, 0xFB,
  0x00, 0x1F, 0xB0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0D, 0xF8, 0x40, 0xDF, 0x84, 0x0D, 0xF8, 0x71, 0xDF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0xE0, 0x3F,
  0x00, 0xFF, 0xE0, 0x7C, 0x03, 0xFF, 0xC1, 0xF8, 0x07, 0xCF, 0x83, 0xE0,
  0x0F, 0x9F, 0x0F, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x7C, 0x00,
  0xF8, 0xF9, 0xF8, 0x01, 0xF3, 0xF3, 0xE0, 0x07, 0xE7, 0xCF, 0xC0, 0x0F,
  0x8F, 0x9F, 0x0F, 0x1F, 0x3F, 0x7E, 0x7F, 0xBF, 0xFC, 0xF9, 0xFF, 0x3F,
  0xFB, 0xE7, 0xFF, 0x7F, 0xE7, 0xDF, 0xFE, 0x7F, 0x9F, 0x3E, 0x7C, 0x7C,
  0x7E, 0x7C, 0xF8, 0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xF3, 0xE3, 0xE0, 0x07,
  0xC7, 0xC7, 0xC0, 0x1F, 0x8F, 0x8F, 0x80, 0x3E, 0x3F, 0x3E, 0x00, 0xF8,
  0x7E, 0x7C, 0x03, 0xF0, 0xFD, 0xF8, 0x07, 0xC0, 0xFB, 0xE0, 0x1F, 0x81,
  0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x9F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF3, 0xFC, 0x1F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFD, 0xFF, 0xF8, 0x7F, 0x3F, 0xFE, 0x3F, 0xCF,
  0xFF, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x87,
  0xE0, 0x31, 0xF0, 0x1F, 0x7C, 0x27, 0xFF, 0x7B, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFD, 0xF8, 0x3E, 0x7F, 0x07, 0x0F, 0x00, 0xC3, 0x80, 0x00,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE7, 0xFF, 0x3F, 0xFB, 0xFF, 0x80, 0x08, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFE, 0xFC, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFB, 0xF8, 0x7F, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC, 0xFE, 0x1F, 0x9F,
  0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x0F, 0xEF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC,
  0x7F, 0x3F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x7D, 0xFC, 0x39,
  0xFC, 0x31, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0x9F, 0xE0, 0x78, 0x7F, 0x01, 0x83,
  0xF8, 0x08, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0E, 0x1F, 0xE0, 0x40, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x10,
  0x07, 0xF8, 0xC0, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xE0, 0x3E, 0x7F,
  0x01, 0xF3, 0xF8, 0x1F, 0x3F, 0x81, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x87, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x88, 0x07, 0xF8, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x7E, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0xFF, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xE1, 0xF8,
  0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF9, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0xC7, 0xF3, 0xF8, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F, 0xBF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFD,
  0xFC, 0x07, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x83, 0xE0, 0x10, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x78, 0xFE,
  0x30, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x87,
  0xFC, 0x78, 0xFC, 0x7F, 0xF3, 0xC7, 0xC7, 0xFF, 0x9E, 0x7C, 0x7F, 0xF8,
  0xF3, 0xE7, 0xE7, 0xC7, 0x9E, 0x3E, 0x3E, 0x3D, 0xF3, 0xE1, 0xF1, 0xEF,
  0x9F, 0x0F, 0x1F, 0x78, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xC7, 0xBE, 0x7C,
  0x3E, 0x3D, 0xF3, 0xE3, 0xF3, 0xEF, 0x9F, 0x1F, 0x1E, 0x7C, 0xF9, 0xF9,
  0xF3, 0xE7, 0xFF, 0xFF, 0x1F, 0x1F, 0xFF, 0xF0, 0xF8, 0xFE, 0x7F, 0x07,
  0xC3, 0xE1, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x81, 0xFC,
  0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x83,
  0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x1F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0x8E, 0x03, 0xFC, 0x08, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x40, 0x7F, 0x83, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xF1,
  0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE,
  0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87,
  0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x3F, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFE,
  0x1E, 0x0F, 0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE3, 0xFF, 0x3F, 0xC7, 0xFE,
  0x7F, 0x9F, 0xF8, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x1F,
  0xC7, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xE0,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F,
  0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFD,
  0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x07, 0xEF, 0xFF, 0x7F, 0x03, 0xFB,
  0xFF, 0xDF, 0xC0, 0xFE, 0xFF, 0xE7, 0xF0, 0x3F, 0xBF, 0xFB, 0xF8, 0x0F,
  0xEF, 0xFC, 0xFE, 0x03, 0xF3, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0xCF, 0xE0,
  0x7F, 0x3F, 0xE3, 0xF0, 0x1F, 0xCF, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x7F,
  0x01, 0xF8, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE3,
  0xF8, 0x0F, 0xE3, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x7F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xF1, 0xFC, 0x07, 0xFF,
  0x1F, 0xC0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF1, 0xF8,
  0x0F, 0xFF, 0x3F, 0x81, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xBF, 0x81, 0xFD,
  0xFB, 0xF8, 0x1F, 0x9F, 0xBF, 0x01, 0xF9, 0xFB, 0xF0, 0x3F, 0x9F, 0xFF,
  0x03, 0xF9, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0x03, 0xF8, 0xFF, 0xE0, 0x3F,
  0x0F, 0xFE, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0x0F, 0xFE, 0x07, 0xF0, 0xFF,
  0xC0, 0x7E, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x7F, 0xC1,
  0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xF9, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC,
  0x7F, 0xBF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xDF, 0x01, 0xFC, 0x18,
  0x0F, 0xF0, 0x20, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x04, 0x03, 0xFC, 0x1C, 0x0F, 0xF0, 0x7C, 0x7F, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF,
  0x81, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F, 0xBF, 0x81, 0xF8,
  0x3F, 0xDF, 0xC1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0x87, 0xF1, 0xFC, 0x7F, 0xC7, 0xF8, 0xFE, 0x3F,
  0xE3, 0xF8, 0x7E, 0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF9, 0xFC, 0x1F, 0x8F,
  0xFC, 0xFE, 0x0F, 0xCF, 0xFC, 0x7F, 0x07, 0xE7, 0xFE, 0x7F, 0x07, 0xF3,
  0xFF, 0x3F, 0x83, 0xFB, 0xFF, 0x9F, 0xC1, 0xFD, 0xFF, 0xDF, 0xC0, 0xFF,
  0xFB, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03,
  0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x87, 0xE0,
  0xFC, 0x03, 0xE3, 0xF8, 0x3F, 0x9F, 0x83, 0xFE, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFE, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC,
  0x3F, 0xBF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0x81, 0xFC,
  0xFC, 0x07, 0xC7, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x9F, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0xBF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xDF, 0xE0, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x08, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x04, 0x7F, 0x04, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8,
  0x3F, 0xBF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xEF, 0xC0, 0x3E, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x9F, 0xCF, 0xE3, 0xFB, 0xF8, 0x7E,
  0x7F, 0x1F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x43,
  0xFC, 0x38, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x03, 0xFD, 0xF8,
  0x0F, 0xFB, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x04,
  0x03, 0xFC, 0x0F, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x9F, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC0, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF3,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xE3, 0xE0, 0xF8, 0x0F, 0xDF, 0xE7, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC,
  0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xE3, 0xFB, 0xFC, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xFD, 0xFC, 0x7F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0xF8, 0x03,
  0xF3, 0xF8, 0x07, 0xEF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x3F, 0xDF, 0x83, 0xFE, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xE4, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFE, 0xF8, 0xFE,
  0x08, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x40, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xF3,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xF3, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFE, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xFF, 0xC3, 0xFB,
  0xF8, 0x7F, 0x7F, 0x1F, 0xEF, 0xE3, 0xF9, 0xF8, 0x7F, 0x3F, 0x1F, 0xC7,
  0xE3, 0xF8, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F,
  0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0xE1, 0xFD, 0xF8, 0x7F, 0x8F, 0xE7,
  0xE3, 0xFE, 0x3F, 0x9F, 0x8F, 0xF9, 0xFC, 0x7E, 0x3F, 0xE7, 0xF1, 0xF9,
  0xFF, 0x9F, 0x87, 0xE7, 0xFE, 0xFE, 0x1F, 0xBF, 0xF3, 0xF8, 0x7E, 0xFF,
  0xCF, 0xC1, 0xFB, 0xFF, 0x7F, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFD, 0xF7,
  0xE0, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0x07, 0xF1, 0xFE, 0x07, 0xF9, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFB,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x9F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x3F, 0xF4, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 14, 32, 11, 0, -31 },
  { 57, 18, 11, 19, 4, -31 },
  { 82, 24, 31, 23, 0, -31 },
  { 175, 20, 36, 20, 1, -33 },
  { 265, 31, 31, 34, 2, -31 },
  { 386, 26, 31, 26, 0, -31 },
  { 487, 9, 11, 10, 4, -31 },
  { 500, 16, 39, 12, 0, -32 },
  { 578, 15, 39, 12, -3, -32 },
  { 652, 18, 20, 19, 3, -33 },
  { 697, 18, 21, 22, 2, -26 },
  { 745, 11, 12, 11, -3, -6 },
  { 762, 13, 7, 13, 0, -15 },
  { 774, 8, 9, 11, 0, -8 },
  { 783, 23, 31, 17, -2, -31 },
  { 873, 19, 31, 20, 1, -31 },
  { 947, 16, 31, 20, 4, -31 },
  { 1009, 21, 31, 20, -1, -31 },
  { 1091, 21, 31, 20, 0, -31 },
  { 1173, 21, 31, 20, 0, -31 },
  { 1255, 20, 31, 20, 1, -31 },
  { 1333, 21, 31, 20, 1, -31 },
  { 1415, 22, 31, 20, 1, -31 },
  { 1501, 21, 31, 20, 0, -31 },
  { 1583, 20, 31, 20, 1, -31 },
  { 1661, 11, 25, 11, 0, -24 },
  { 1696, 14, 30, 11, -3, -24 },
  { 1749, 18, 21, 22, 2, -26 },
  { 1797, 18, 15, 22, 2, -23 },
  { 1831, 19, 21, 22, 2, -26 },
  { 1881, 17, 32, 16, 1, -31 },
  { 1949, 29, 34, 30, 1, -31 },
  { 2073, 23, 31, 23, -3, -31 },
  { 2163, 23, 31, 22, 0, -31 },
  { 2253, 22, 31, 20, 1, -31 },
  { 2339, 23, 31, 23, 0, -31 },
  { 2429, 20, 31, 18, 0, -31 },
  { 2507, 20, 31, 18, 0, -31 },
  { 2585, 23, 31, 24, 2, -31 },
  { 2675, 26, 31, 24, 0, -31 },
  { 2776, 21, 31, 16, -2, -31 },
  { 2858, 21, 41, 12, -7, -31 },
  { 2966, 26, 31, 22, 0, -31 },
  { 3067, 15, 31, 17, 0, -31 },
  { 3126, 34, 31, 32, 0, -31 },
  { 3258, 28, 31, 26, 0, -31 },
  { 3367, 24, 31, 25, 1, -31 },
  { 3460, 22, 31, 21, 0, -31 },
  { 3546, 24, 38, 25, 1, -31 },
  { 3660, 22, 31, 22, 0, -31 },
  { 3746, 22, 31, 19, -1, -31 },
  { 3832, 19, 31, 18, 3, -31 },
  { 3906, 24, 31, 23, 1, -31 },
  { 3999, 22, 31, 22, 4, -31 },
  { 4085, 33, 31, 32, 3, -31 },
  { 4213, 28, 31, 22, -3, -31 },
  { 4322, 21, 31, 21, 4, -31 },
  { 4404, 24, 31, 19, -2, -31 },
  { 4497, 18, 39, 12, -2, -32 },
  { 4585, 10, 31, 17, 4, -31 },
  { 4624, 18, 39, 12, -3, -32 },
  { 4712, 21, 21, 20, -1, -31 },
  { 4768, 18, 5, 17, -4, 3 },
  { 4780, 10, 7, 14, 6, -33 },
  { 4789, 21, 24, 21, 1, -24 },
  { 4852, 21, 33, 21, -1, -33 },
  { 4939, 17, 24, 17, 1, -24 },
  { 4990, 22, 33, 21, 1, -33 },
  { 5081, 19, 24, 20, 1, -24 },
  { 5138, 23, 43, 13, -5, -33 },
  { 5262, 23, 34, 21, -1, -24 },
  { 5360, 21, 33, 21, -1, -33 },
  { 5447, 14, 33, 11, -1, -33 },
  { 5505, 18, 43, 11, -5, -33 },
  { 5602, 24, 33, 21, -1, -33 },
  { 5701, 14, 33, 11, -1, -33 },
  { 5759, 31, 24, 31, -1, -24 },
  { 5852, 21, 24, 21, -1, -24 },
  { 5915, 19, 24, 21, 1, -24 },
  { 5972, 23, 34, 21, -3, -24 },
  { 6070, 21, 34, 21, 1, -24 },
  { 6160, 18, 24, 15, -1, -24 },
  { 6214, 17, 24, 17, 0, -24 },
  { 6265, 14, 29, 15, 2, -29 },
  { 6316, 21, 24, 21, 1, -24 },
  { 6379, 19, 24, 20, 3, -24 },
  { 6436, 30, 24, 29, 2, -24 },
  { 6526, 24, 24, 20, -2, -24 },
  { 6598, 25, 34, 20, -3, -24 },
  { 6705, 20, 24, 17, -2, -24 },
  { 6765, 18, 38, 15, 0, -31 },
  { 6851, 6, 43, 17, 5, -33 },
  { 6884, 18, 38, 15, -3, -31 },
  { 6970, 19, 8, 22, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC43PT7B_H_
