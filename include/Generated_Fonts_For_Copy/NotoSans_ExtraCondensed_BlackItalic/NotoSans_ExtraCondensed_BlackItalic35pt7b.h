#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x7E, 0xFC, 0xF9, 0xFB, 0xF3, 0xE7, 0xE7, 0xCF, 0xCF, 0x9F, 0x1F,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0x3E, 0x00, 0xF3,
  0xC0, 0x1F, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x81, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0x62, 0x0F, 0xB0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x10, 0x6F,
  0x8C, 0x37, 0xC7, 0x9F, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xC0,
  0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xF8, 0x3C, 0x07, 0xFC, 0x3E, 0x07, 0x9E,
  0x1E, 0x03, 0xCF, 0x1F, 0x03, 0xE7, 0x8F, 0x01, 0xE3, 0xCF, 0x00, 0xF3,
  0xEF, 0x80, 0x79, 0xE7, 0x80, 0x3C, 0xF7, 0xCF, 0x9F, 0xFB, 0xCF, 0xEF,
  0xFB, 0xEF, 0xFB, 0xF9, 0xEF, 0xFD, 0xF9, 0xE7, 0x9E, 0x00, 0xF7, 0xCF,
  0x00, 0xF3, 0xC7, 0x80, 0xF9, 0xE3, 0xC0, 0x78, 0xF3, 0xC0, 0x7C, 0x79,
  0xE0, 0x3C, 0x3C, 0xF0, 0x3E, 0x1F, 0xF0, 0x1E, 0x0F, 0xF8, 0x1E, 0x03,
  0xF8, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF3,
  0xF0, 0xFF, 0x9F, 0x8F, 0xFD, 0xF8, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0x7C,
  0xFF, 0xC7, 0xE3, 0xFE, 0x3F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0x7E,
  0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x7C, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x81, 0x1E, 0x07, 0xBC,
  0x2F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0x81,
  0xFF, 0x87, 0xEF, 0x87, 0x9F, 0x07, 0x3C, 0x04, 0x20, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0xFF, 0x80,
  0x3D, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xBF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xFD, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF1, 0xEF,
  0xC3, 0x3E, 0x09, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3C, 0xFC, 0x0C, 0x7E, 0x04, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x30, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x90, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xBE, 0x03, 0xFF,
  0x03, 0xDF, 0x81, 0xEF, 0xC1, 0xE7, 0xC1, 0xE7, 0xE1, 0xF3, 0xF0, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x81, 0xFC, 0x81,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x20, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xE3, 0xF7, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xF8, 0x7C, 0x7C,
  0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x7E, 0x7E, 0x3E,
  0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xEF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0x7C, 0x06, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x0F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x03,
  0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x01, 0xC0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFC, 0xC3, 0xF2, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7C,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x1F, 0x8F, 0x1E, 0x7F, 0xEF,
  0x3C, 0x7F, 0xCF, 0x3C, 0xF3, 0xCF, 0x79, 0xE3, 0xCF, 0x79, 0xE3, 0xCF,
  0x73, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF, 0x9C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x78, 0xF3, 0xFF, 0xF8, 0xF3, 0xF7, 0xF0,
  0xF1, 0xE3, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3,
  0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF7, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xDF, 0xC1,
  0xF9, 0xF8, 0x3E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xF0, 0x81, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x60, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x9F, 0xC3,
  0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x7F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xC1, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF9, 0xFF, 0x3F, 0x3F, 0xC7, 0xE7, 0xF8, 0xFC, 0xFF, 0x3F, 0x9F,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x09, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7C, 0x7F, 0x03, 0xF1, 0xF8, 0x0F,
  0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF8,
  0x0F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF, 0xF8, 0x7F, 0xF7,
  0xBF, 0x0F, 0xFF, 0xF7, 0xC1, 0xF7, 0xFD, 0xF8, 0x3E, 0xFF, 0xBF, 0x0F,
  0xDF, 0xF7, 0xE1, 0xFB, 0xFC, 0xF8, 0x3F, 0x7F, 0x9F, 0x07, 0xCF, 0xE7,
  0xE0, 0xF9, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE7, 0xE3, 0xE0, 0xF8,
  0xF8, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0,
  0x7F, 0x87, 0xE0, 0xFF, 0x0F, 0xC1, 0xFF, 0x1F, 0x03, 0xFE, 0x3E, 0x07,
  0xFC, 0x7C, 0x1F, 0xF9, 0xF8, 0x3F, 0xF3, 0xF0, 0x7F, 0xE7, 0xC0, 0xFF,
  0xEF, 0x83, 0xF7, 0xDF, 0x07, 0xEF, 0xFE, 0x0F, 0xDF, 0xFC, 0x1F, 0x3F,
  0xF0, 0x3E, 0x7F, 0xE0, 0xFC, 0xFF, 0xC1, 0xF8, 0xFF, 0x83, 0xE1, 0xFE,
  0x07, 0xC3, 0xFC, 0x0F, 0x87, 0xF8, 0x3F, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0,
  0xF8, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xEF, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFF, 0xFC, 0x1F,
  0xBF, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0xFE,
  0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x83, 0xF7,
  0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0xFE, 0x7F, 0x3F, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7,
  0xF1, 0xF9, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xF3, 0xF1, 0xFC, 0xFC, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF8,
  0xC0, 0xFC, 0x10, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x86, 0x07, 0xE1, 0xE3, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7C,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xE0, 0xFD, 0xF8, 0x1F, 0x7E, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0x87, 0xEF, 0xC3,
  0xF0, 0xFD, 0xF8, 0x7E, 0x3F, 0x3F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF0, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xC7, 0xE3, 0xE3, 0xF8, 0xF8, 0x7C, 0xFF,
  0x3F, 0x0F, 0x9F, 0xE7, 0xE1, 0xF3, 0xFC, 0xF8, 0x3E, 0xFF, 0xBF, 0x07,
  0xDF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0xFF,
  0xC0, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xDF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0x9F, 0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F,
  0x87, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xFE, 0x1F, 0x9F, 0x8F, 0xCF,
  0xCF, 0xC7, 0xE7, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xF8,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x03,
  0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F, 0x01, 0x80, 0x41, 0xFB, 0xE0, 0xFE,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xE3, 0xF3, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xF7,
  0xC0, 0xF9, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x38, 0x1F, 0xBE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFB, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3,
  0xF3, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3C, 0xF8,
  0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xFC, 0x47,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC2, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0C, 0x7E, 0x07, 0xEF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFB, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF9, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xEF, 0x80, 0xF9, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x3F, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC7, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x04, 0x7E, 0x18, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE4, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x20, 0x7E, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xE0,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xBF, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x20,
  0x3F, 0x07, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x38, 0x1F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFB, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x7E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE7, 0xE3, 0xE3,
  0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x7E, 0x3E, 0x3F, 0x00,
  0x03, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x01, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x9F,
  0x81, 0xF7, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFE, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x00, 0x00, 0x1C, 0x0C, 0x0F, 0xBF, 0x9F, 0x87, 0xFF, 0xDF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFC, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF1,
  0xF9, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x7E, 0x3E, 0x3F,
  0x3F, 0x1F, 0x1F, 0x1F, 0x9F, 0x80, 0x00, 0x18, 0x0F, 0xBF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFD, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F,
  0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF1,
  0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F, 0x1F,
  0x80, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF,
  0xDF, 0x8F, 0xBE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x87, 0xDF, 0x1F, 0xBE, 0x3F, 0x7E, 0xFC, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x07, 0x00, 0xF9, 0xF0, 0x1F, 0x7F, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFB, 0xF8,
  0x1F, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0,
  0x41, 0xFB, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xE3,
  0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFB, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x1C, 0x7C, 0xF1, 0xF7, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFC, 0x8F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0xFC, 0x43, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xC8, 0x3F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x3F, 0x1F,
  0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x7C,
  0x1F, 0x3E, 0x00, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xFD, 0xF8, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x7E, 0xFC,
  0xFE, 0x7E, 0xF9, 0xFE, 0x7C, 0xF9, 0xFE, 0xFC, 0xF9, 0xFE, 0xF8, 0xFB,
  0xFE, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xBD, 0xF0, 0xFF,
  0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xF0, 0xFE,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3E, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x0C, 0x00, 0x00, 0x08, 0x01, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 25, 9, 0, -25 },
  { 36, 15, 9, 16, 3, -25 },
  { 53, 20, 25, 18, 0, -25 },
  { 116, 17, 29, 17, 0, -27 },
  { 178, 25, 25, 28, 2, -25 },
  { 257, 21, 25, 21, 0, -25 },
  { 323, 7, 9, 8, 3, -25 },
  { 331, 13, 32, 10, 0, -26 },
  { 383, 13, 32, 10, -3, -26 },
  { 435, 15, 16, 15, 2, -27 },
  { 465, 15, 17, 18, 2, -21 },
  { 497, 9, 10, 9, -2, -5 },
  { 509, 10, 5, 11, 0, -12 },
  { 516, 6, 6, 9, 0, -6 },
  { 521, 19, 25, 14, -2, -25 },
  { 581, 16, 25, 17, 1, -25 },
  { 631, 14, 25, 17, 3, -25 },
  { 675, 17, 25, 17, -1, -25 },
  { 729, 17, 25, 17, 0, -25 },
  { 783, 17, 25, 17, 0, -25 },
  { 837, 16, 25, 17, 1, -25 },
  { 887, 17, 25, 17, 1, -25 },
  { 941, 17, 25, 17, 1, -25 },
  { 995, 17, 25, 17, 0, -25 },
  { 1049, 17, 25, 17, 0, -25 },
  { 1103, 9, 20, 9, 0, -20 },
  { 1126, 11, 25, 9, -2, -20 },
  { 1161, 16, 17, 18, 1, -21 },
  { 1195, 15, 13, 18, 2, -19 },
  { 1220, 15, 17, 18, 2, -21 },
  { 1252, 14, 25, 13, 1, -25 },
  { 1296, 24, 28, 25, 1, -25 },
  { 1380, 19, 25, 19, -2, -25 },
  { 1440, 19, 25, 18, 0, -25 },
  { 1500, 18, 25, 16, 1, -25 },
  { 1557, 19, 25, 19, 0, -25 },
  { 1617, 16, 25, 15, 0, -25 },
  { 1667, 16, 25, 14, 0, -25 },
  { 1717, 19, 25, 19, 1, -25 },
  { 1777, 21, 25, 20, 0, -25 },
  { 1843, 17, 25, 13, -1, -25 },
  { 1897, 17, 33, 10, -6, -25 },
  { 1968, 22, 25, 18, 0, -25 },
  { 2037, 13, 25, 14, 0, -25 },
  { 2078, 27, 25, 26, 0, -25 },
  { 2163, 23, 25, 21, 0, -25 },
  { 2235, 19, 25, 20, 1, -25 },
  { 2295, 18, 25, 17, 0, -25 },
  { 2352, 19, 31, 20, 1, -25 },
  { 2426, 18, 25, 18, 0, -25 },
  { 2483, 18, 25, 15, -1, -25 },
  { 2540, 15, 25, 15, 3, -25 },
  { 2587, 20, 25, 19, 1, -25 },
  { 2650, 18, 25, 18, 3, -25 },
  { 2707, 27, 25, 26, 2, -25 },
  { 2792, 22, 25, 18, -2, -25 },
  { 2861, 17, 25, 17, 3, -25 },
  { 2915, 19, 25, 15, -1, -25 },
  { 2975, 15, 32, 10, -2, -26 },
  { 3035, 9, 25, 14, 3, -25 },
  { 3064, 15, 32, 10, -3, -26 },
  { 3124, 17, 17, 16, -1, -25 },
  { 3161, 14, 4, 13, -3, 2 },
  { 3168, 8, 6, 12, 5, -27 },
  { 3174, 18, 20, 17, 0, -20 },
  { 3219, 17, 27, 17, 0, -27 },
  { 3277, 14, 20, 14, 1, -20 },
  { 3312, 19, 27, 17, 0, -27 },
  { 3377, 15, 20, 16, 1, -20 },
  { 3415, 19, 35, 11, -4, -27 },
  { 3499, 19, 28, 17, -1, -20 },
  { 3566, 17, 27, 17, 0, -27 },
  { 3624, 11, 27, 9, 0, -27 },
  { 3662, 15, 35, 9, -4, -27 },
  { 3728, 19, 27, 17, 0, -27 },
  { 3793, 11, 27, 9, 0, -27 },
  { 3831, 25, 20, 25, 0, -20 },
  { 3894, 17, 20, 17, 0, -20 },
  { 3937, 15, 20, 17, 1, -20 },
  { 3975, 19, 28, 17, -2, -20 },
  { 4042, 18, 28, 17, 0, -20 },
  { 4105, 14, 20, 12, 0, -20 },
  { 4140, 14, 20, 14, 0, -20 },
  { 4175, 12, 23, 12, 1, -23 },
  { 4210, 17, 19, 17, 1, -19 },
  { 4251, 16, 19, 16, 2, -19 },
  { 4289, 24, 19, 24, 2, -19 },
  { 4346, 20, 19, 16, -2, -19 },
  { 4394, 20, 27, 16, -2, -19 },
  { 4462, 16, 19, 14, -1, -19 },
  { 4500, 15, 31, 12, 0, -25 },
  { 4559, 5, 35, 14, 4, -27 },
  { 4581, 14, 31, 12, -2, -25 },
  { 4636, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC35PT7B_H_
