#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x00, 0x0E, 0x38, 0xE0, 0xEF,
  0xDF, 0xB6, 0x6D, 0xC0, 0x0E, 0xC3, 0x60, 0xD8, 0x66, 0x7F, 0xDF, 0xF3,
  0xB0, 0xD8, 0xFF, 0xBF, 0xE6, 0xE1, 0xB0, 0xEC, 0x00, 0x02, 0x02, 0x07,
  0xE7, 0xE3, 0x51, 0xA0, 0xF0, 0x7C, 0x0E, 0x07, 0x95, 0x9F, 0xCF, 0xC0,
  0x80, 0x40, 0x38, 0x63, 0xE6, 0x1B, 0x31, 0x9B, 0x0D, 0xB8, 0x6D, 0xBB,
  0xFF, 0xEE, 0xDB, 0x0D, 0xD8, 0x6C, 0xC6, 0x6C, 0x33, 0xE3, 0x0E, 0x00,
  0x0F, 0x03, 0xF0, 0x6E, 0x1D, 0xC3, 0xF0, 0x3C, 0x0F, 0xBB, 0xFE, 0xEF,
  0xDC, 0xF3, 0xBE, 0x7F, 0xC7, 0xFC, 0xFF, 0xEC, 0x0E, 0x38, 0xE1, 0xC3,
  0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0xCE, 0x30, 0x1C, 0x1C,
  0x79, 0xFF, 0x3F, 0x3C, 0x7E, 0x2C, 0x08, 0x38, 0x38, 0x38, 0xFF, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x37, 0x76, 0xEC, 0x7F, 0xFE, 0xFF, 0x80, 0x01,
  0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x3E, 0x7E, 0x77, 0xE7, 0xE6, 0xEE, 0xEE,
  0xCE, 0xCC, 0xFC, 0xF8, 0xF0, 0x0E, 0x79, 0xF7, 0xEF, 0xCF, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x00, 0x07, 0x0F, 0xC7, 0xE2, 0x70, 0x38, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0xCF, 0xEF, 0xF0, 0x1F, 0x1F, 0x8F, 0xE0,
  0x70, 0x70, 0xF0, 0xF0, 0x7C, 0x0F, 0x07, 0x37, 0x9F, 0xCF, 0x80, 0x03,
  0x83, 0x83, 0xC1, 0xE1, 0xF1, 0xB8, 0xF8, 0xDC, 0xFF, 0x7F, 0xBF, 0xC3,
  0x81, 0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0x03, 0x81, 0xF1, 0xFC, 0x1E, 0x07,
  0x07, 0xB7, 0x9F, 0xCF, 0xC0, 0x0F, 0x1F, 0x3F, 0x70, 0x64, 0xFE, 0xFE,
  0xEE, 0xEE, 0xCE, 0xFC, 0xFC, 0x78, 0x3F, 0xCF, 0xE3, 0xF8, 0x0C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x00, 0x0F,
  0x0F, 0xCE, 0xE7, 0x73, 0xF1, 0xF0, 0xF8, 0xFC, 0x77, 0x73, 0xBB, 0x9F,
  0xC7, 0xC0, 0x0E, 0x1F, 0x8F, 0xCE, 0x77, 0x3B, 0xB9, 0xFC, 0xFE, 0x37,
  0x07, 0x27, 0x9F, 0x8F, 0x80, 0x39, 0xDC, 0x00, 0x00, 0x0C, 0xE7, 0x00,
  0x1C, 0x73, 0x80, 0x00, 0x00, 0x0C, 0x71, 0xC6, 0x38, 0xC0, 0x01, 0x0F,
  0x3F, 0xFC, 0xE0, 0xF8, 0x3F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x3D,
  0xF9, 0xFC, 0x61, 0xC7, 0x1C, 0x30, 0x00, 0x03, 0x87, 0x0C, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0x0C, 0x67, 0x33, 0x7D, 0xB6, 0x6D, 0xB6, 0x6D, 0xB6,
  0xDD, 0xB6, 0x7F, 0x33, 0xB0, 0xC0, 0x07, 0x18, 0x1F, 0xC0, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0x61, 0xD8, 0xE6, 0x3F, 0x9F, 0xE7, 0xF9,
  0xCF, 0xE3, 0xC0, 0x1F, 0x0F, 0xE3, 0xFC, 0xEF, 0x3B, 0x9F, 0xE7, 0xF1,
  0xFC, 0x77, 0x9D, 0xCF, 0xF3, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x9F, 0xCE,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x1F, 0x87, 0xC0, 0x1F,
  0x0F, 0xE3, 0xFC, 0xEF, 0x39, 0xDE, 0x77, 0x3D, 0xCE, 0x73, 0x9D, 0xEF,
  0xF3, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x3F, 0x38, 0x38, 0x7E, 0x7E, 0x7E,
  0x70, 0x70, 0xFC, 0xFC, 0xFC, 0x1F, 0x3F, 0x3F, 0x38, 0x38, 0x7E, 0x7E,
  0x7E, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x0F, 0x9F, 0xCF, 0xEE, 0x0F, 0x07,
  0x7F, 0xBD, 0xDE, 0xE7, 0x73, 0xBF, 0xDF, 0xC7, 0xE0, 0x1C, 0xE7, 0x1C,
  0xE7, 0x1C, 0xE3, 0x9C, 0xFF, 0x9F, 0xF3, 0xFC, 0x73, 0x8E, 0x73, 0x8E,
  0x73, 0x8E, 0x70, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x0F, 0xCF, 0xC0, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE1, 0xE1, 0xF0,
  0xF0, 0x00, 0x1C, 0xE7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0E, 0xE3, 0x9C, 0x73, 0x8E, 0x70, 0x1C, 0xE3, 0x8E, 0x39,
  0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0xFC, 0x1E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF,
  0xBE, 0x3E, 0xF9, 0xFB, 0xE7, 0xFF, 0x9F, 0xEE, 0x7F, 0xF1, 0xBD, 0xCE,
  0xF7, 0x3B, 0x9C, 0xEE, 0xE0, 0x1C, 0x73, 0xC6, 0x3C, 0xE3, 0xEE, 0x3E,
  0xE7, 0xEC, 0x7F, 0xC7, 0x7C, 0x77, 0xC6, 0x7C, 0xE7, 0x8E, 0x78, 0xE7,
  0x80, 0x1F, 0x1F, 0xDF, 0xEE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3,
  0xBF, 0xDF, 0xC7, 0xC0, 0x1F, 0x1F, 0xCF, 0xE7, 0x73, 0xBB, 0x9D, 0xFC,
  0xFE, 0x7C, 0x38, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0x1F, 0xDF, 0xEE, 0x7F,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xBF, 0xDF, 0xC7, 0xC0, 0xE0, 0x70,
  0x3C, 0x1F, 0x1F, 0xCF, 0xE7, 0x73, 0xBB, 0xFD, 0xFC, 0xFC, 0x7E, 0x3F,
  0x39, 0xDC, 0xEE, 0x70, 0x1F, 0x1F, 0xCF, 0xCF, 0x27, 0x81, 0xE0, 0xF8,
  0x3C, 0x0E, 0x47, 0x3F, 0x9F, 0x8F, 0x80, 0x7F, 0x7F, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x39, 0xDC, 0xE7, 0x39,
  0xCE, 0x73, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xE3, 0xF8, 0x7C,
  0x00, 0xE3, 0xF3, 0xB9, 0xDD, 0xEE, 0xE7, 0x73, 0xF1, 0xF8, 0xD8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x00, 0x73, 0x9D, 0xCE, 0x76, 0x73, 0x99, 0xCE, 0x6F,
  0x73, 0xBD, 0xCE, 0xF7, 0x3F, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C,
  0xF0, 0xF3, 0x80, 0x1C, 0xE3, 0xB8, 0x77, 0x0F, 0xC0, 0xF8, 0x1E, 0x03,
  0x80, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x39, 0xCE, 0x38, 0xE7, 0xE7, 0xEE,
  0xEE, 0xFC, 0xF8, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x1F, 0xC7,
  0xF1, 0xFC, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0xF1,
  0xFC, 0xFF, 0x00, 0x1F, 0x1E, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x60, 0x60, 0xF8, 0xF0, 0xCC, 0xEE, 0xEE, 0x66, 0x67,
  0x77, 0x70, 0x1E, 0x3C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x06, 0x3C, 0x78, 0x06, 0x0E, 0x0E, 0x1E, 0x3F, 0x37, 0x77, 0xE3,
  0xC3, 0x7F, 0xFE, 0xEE, 0x70, 0x1F, 0x9F, 0xDD, 0xCE, 0xE7, 0x77, 0x3B,
  0x9D, 0xDC, 0xFE, 0x3B, 0x00, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0xF1, 0xF9,
  0xFE, 0xE7, 0x77, 0x3B, 0x99, 0xDF, 0xEF, 0xE6, 0xE0, 0x1F, 0x3E, 0x7A,
  0x70, 0x70, 0xE0, 0xE0, 0xF4, 0x7C, 0x7C, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x1F, 0x8F, 0xE7, 0x71, 0xDC, 0x77, 0x39, 0xCE, 0x73, 0xB8, 0xFE, 0x1D,
  0x80, 0x1E, 0x3F, 0x73, 0x77, 0x7F, 0xFC, 0xE0, 0xE2, 0x7E, 0x7C, 0x03,
  0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x00, 0x0F, 0xC7,
  0xF3, 0xB8, 0xEE, 0x3B, 0x9C, 0xE7, 0x39, 0xDC, 0x7F, 0x0F, 0xC0, 0x72,
  0x3C, 0xFE, 0x3F, 0x00, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0xF1, 0xF9, 0xFE,
  0xEE, 0x77, 0x3B, 0x99, 0xDC, 0xEE, 0xE7, 0x70, 0x19, 0xCE, 0x03, 0x99,
  0xCE, 0x73, 0x99, 0xCE, 0x70, 0x06, 0x1C, 0x38, 0x00, 0xE1, 0x87, 0x0E,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x38, 0xF1, 0xC0, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x3B, 0xCC, 0xE7, 0x71, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xB8,
  0xEE, 0x39, 0xC0, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0xC6, 0x38,
  0xE3, 0x80, 0x37, 0x71, 0xFF, 0xDF, 0xFE, 0xEE, 0x77, 0x77, 0x3B, 0xB9,
  0x9D, 0xDC, 0xCE, 0xEE, 0x77, 0x77, 0x00, 0x37, 0x1F, 0x9F, 0xEE, 0xE7,
  0x73, 0xB9, 0x9D, 0xCE, 0xEE, 0x77, 0x00, 0x1E, 0x3F, 0x77, 0x77, 0x77,
  0xE7, 0xE7, 0xEE, 0x7E, 0x7C, 0x1B, 0x87, 0xE3, 0xFC, 0xE7, 0x3B, 0x8E,
  0xE3, 0x39, 0xFE, 0x7F, 0x1F, 0x87, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0x9F, 0xDD, 0xCE, 0xE7, 0x77, 0x3B, 0x9D, 0xDC, 0xFE, 0x3F, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x36, 0x7D, 0xFB, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC0,
  0x3E, 0xFD, 0xD3, 0x87, 0x87, 0x87, 0x4E, 0xFD, 0xF0, 0x38, 0xC7, 0xFE,
  0x73, 0x8E, 0x38, 0xE3, 0xAF, 0x3C, 0x3B, 0x99, 0xDC, 0xEE, 0xE7, 0x73,
  0xBB, 0x9D, 0xFE, 0xFE, 0x3B, 0x00, 0xE7, 0xE7, 0xEE, 0xEE, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF0, 0x70, 0xEF, 0x7E, 0xF7, 0xEF, 0xEF, 0xFE, 0xFE, 0xCF,
  0xFC, 0xF7, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0x39, 0xC7, 0xE1, 0xF8, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xFC, 0x77, 0x39, 0xC0, 0x39, 0xCE, 0x73, 0xB8,
  0xEE, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xF0,
  0x38, 0x00, 0x3F, 0x9F, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x7E,
  0x7F, 0x00, 0x07, 0x1E, 0x1E, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x18, 0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x07, 0x1E, 0x78, 0xE1, 0xC7,
  0x1E, 0x3C, 0x70, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 10, 13, 10, 0, -13 },
  { 33, 9, 15, 9, 0, -14 },
  { 50, 13, 13, 14, 1, -13 },
  { 72, 11, 13, 11, 0, -13 },
  { 90, 3, 5, 4, 2, -13 },
  { 92, 7, 16, 5, 0, -13 },
  { 106, 6, 16, 5, -1, -13 },
  { 118, 8, 9, 8, 1, -14 },
  { 127, 8, 9, 9, 1, -11 },
  { 136, 4, 6, 5, -1, -3 },
  { 139, 5, 3, 6, 0, -6 },
  { 141, 3, 3, 5, 0, -3 },
  { 143, 10, 13, 7, -1, -13 },
  { 160, 8, 13, 9, 1, -13 },
  { 173, 7, 13, 9, 2, -13 },
  { 185, 9, 13, 9, -1, -13 },
  { 200, 9, 13, 9, 0, -13 },
  { 215, 9, 13, 9, 0, -13 },
  { 230, 9, 13, 9, 0, -13 },
  { 245, 8, 13, 9, 1, -13 },
  { 258, 10, 13, 9, 0, -13 },
  { 275, 9, 13, 9, 0, -13 },
  { 290, 9, 13, 9, 0, -13 },
  { 305, 5, 10, 5, 0, -10 },
  { 312, 6, 13, 5, -1, -10 },
  { 322, 8, 9, 9, 1, -11 },
  { 331, 8, 7, 9, 1, -10 },
  { 338, 8, 9, 9, 1, -11 },
  { 347, 7, 13, 7, 1, -13 },
  { 359, 13, 14, 13, 0, -13 },
  { 382, 10, 13, 10, -1, -13 },
  { 399, 10, 13, 9, 0, -13 },
  { 416, 9, 13, 8, 1, -13 },
  { 431, 10, 13, 10, 0, -13 },
  { 448, 8, 13, 8, 0, -13 },
  { 461, 8, 13, 7, 0, -13 },
  { 474, 9, 13, 10, 1, -13 },
  { 489, 11, 13, 10, 0, -13 },
  { 507, 9, 13, 7, -1, -13 },
  { 522, 9, 17, 5, -3, -13 },
  { 542, 11, 13, 9, 0, -13 },
  { 560, 6, 13, 7, 0, -13 },
  { 570, 14, 13, 13, 0, -13 },
  { 593, 12, 13, 11, 0, -13 },
  { 613, 9, 13, 10, 1, -13 },
  { 628, 9, 13, 9, 0, -13 },
  { 643, 9, 16, 10, 1, -13 },
  { 661, 9, 13, 9, 0, -13 },
  { 676, 9, 13, 8, 0, -13 },
  { 691, 8, 13, 8, 1, -13 },
  { 704, 10, 13, 10, 1, -13 },
  { 721, 9, 13, 9, 2, -13 },
  { 736, 14, 13, 13, 1, -13 },
  { 759, 11, 13, 9, -1, -13 },
  { 777, 8, 13, 9, 2, -13 },
  { 790, 10, 13, 8, -1, -13 },
  { 807, 8, 16, 5, -1, -13 },
  { 823, 4, 13, 7, 2, -13 },
  { 830, 7, 16, 5, -1, -13 },
  { 844, 8, 9, 8, 0, -13 },
  { 853, 8, 2, 7, -2, 1 },
  { 855, 4, 3, 6, 3, -14 },
  { 857, 9, 10, 9, 0, -10 },
  { 869, 9, 14, 9, 0, -14 },
  { 885, 8, 10, 7, 0, -10 },
  { 895, 10, 14, 9, 0, -14 },
  { 913, 8, 10, 8, 0, -10 },
  { 923, 10, 18, 6, -2, -14 },
  { 946, 10, 14, 9, -1, -10 },
  { 964, 9, 14, 9, 0, -14 },
  { 980, 5, 14, 5, 0, -14 },
  { 989, 7, 18, 5, -2, -14 },
  { 1005, 10, 14, 9, 0, -14 },
  { 1023, 6, 14, 5, 0, -14 },
  { 1034, 13, 10, 13, 0, -10 },
  { 1051, 9, 10, 9, 0, -10 },
  { 1063, 8, 10, 9, 0, -10 },
  { 1073, 10, 14, 9, -1, -10 },
  { 1091, 9, 14, 9, 0, -10 },
  { 1107, 7, 10, 6, 0, -10 },
  { 1116, 7, 10, 7, 0, -10 },
  { 1125, 6, 12, 6, 1, -12 },
  { 1134, 9, 10, 9, 0, -10 },
  { 1146, 8, 10, 8, 1, -10 },
  { 1156, 12, 10, 12, 1, -10 },
  { 1171, 10, 10, 8, -1, -10 },
  { 1184, 10, 14, 8, -1, -10 },
  { 1202, 9, 10, 7, -1, -10 },
  { 1214, 8, 16, 6, 0, -13 },
  { 1230, 3, 18, 7, 2, -14 },
  { 1237, 7, 16, 6, -1, -13 },
  { 1251, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC18PT7B_H_
