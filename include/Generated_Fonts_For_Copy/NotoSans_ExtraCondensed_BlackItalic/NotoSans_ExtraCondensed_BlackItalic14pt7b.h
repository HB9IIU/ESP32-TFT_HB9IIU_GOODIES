#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x00, 0xEC, 0x6D, 0xBD, 0xB6, 0x1B, 0x1E, 0x16,
  0x7F, 0x34, 0x2C, 0xFE, 0x68, 0x58, 0xD8, 0x08, 0x38, 0xFB, 0x67, 0x07,
  0x07, 0x0E, 0xDD, 0xF0, 0x81, 0x00, 0x73, 0x3C, 0xCD, 0x62, 0xD0, 0xFD,
  0xBA, 0xF1, 0xAC, 0xDB, 0x37, 0x98, 0xC0, 0x1E, 0x3E, 0x36, 0x3C, 0x3B,
  0x7B, 0xFE, 0xCE, 0xFE, 0x7F, 0x6F, 0x60, 0x19, 0x8C, 0xC6, 0x33, 0x18,
  0xC6, 0x31, 0x80, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x33, 0x19, 0x80, 0x32,
  0xCF, 0xDF, 0x73, 0x65, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x76, 0x6C,
  0x7F, 0xF8, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0,
  0x1C, 0x7D, 0xDB, 0x76, 0xED, 0xBB, 0x7E, 0x78, 0xE0, 0x1C, 0xE7, 0xB6,
  0x78, 0xC3, 0x0C, 0x31, 0xC0, 0x3C, 0xFC, 0xB8, 0x61, 0xC3, 0x0C, 0x30,
  0xF9, 0xF0, 0x3C, 0x7C, 0xB8, 0x63, 0x87, 0x87, 0x4E, 0xF9, 0xE0, 0x0E,
  0x18, 0x71, 0xE6, 0xCB, 0xBF, 0x7E, 0x18, 0x70, 0x3E, 0x7C, 0xC3, 0xC7,
  0xCB, 0x83, 0x4E, 0xF9, 0xE0, 0x1E, 0x7C, 0xC3, 0x47, 0xCD, 0xBB, 0x76,
  0x7C, 0xF0, 0x3E, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x71, 0xC0, 0x1C,
  0x7D, 0xD9, 0xE3, 0x8F, 0xBB, 0x66, 0xFC, 0xF0, 0x3C, 0x79, 0xFB, 0x76,
  0xEF, 0x8B, 0x0C, 0xF9, 0xE0, 0x37, 0x60, 0x00, 0xEC, 0x19, 0xCC, 0x00,
  0x01, 0xCC, 0x66, 0x00, 0x04, 0x77, 0xF8, 0xE0, 0xF0, 0xC0, 0xFC, 0x00,
  0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x3F, 0xCC, 0x00, 0x39, 0xF4, 0xC6, 0x39,
  0xC0, 0x00, 0x63, 0x80, 0x0F, 0x86, 0x63, 0x6D, 0xBF, 0x5A, 0xD4, 0xBD,
  0x6B, 0x7E, 0xC0, 0x18, 0x83, 0xE0, 0x0E, 0x0F, 0x1F, 0x1F, 0x1F, 0x37,
  0x3F, 0x7F, 0x67, 0xE7, 0x3E, 0x7C, 0xDB, 0xB7, 0xCF, 0x9B, 0xF7, 0xFD,
  0xF0, 0x1E, 0x7C, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0x78, 0xF0, 0x3C, 0x3E,
  0x37, 0x77, 0x67, 0x66, 0x66, 0xEE, 0xFC, 0xF8, 0x3E, 0x78, 0xC3, 0x87,
  0xCF, 0x18, 0x70, 0xF9, 0xF0, 0x3E, 0x78, 0xC3, 0x87, 0xCF, 0x18, 0x70,
  0xE1, 0x80, 0x1F, 0x3F, 0x30, 0x70, 0x6E, 0x6E, 0xE6, 0x6E, 0x7E, 0x7C,
  0x33, 0x33, 0x33, 0x77, 0x7E, 0x7E, 0x66, 0xE6, 0xEE, 0xCC, 0x3E, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x79, 0xF0, 0x0C, 0x30, 0xC7, 0x18, 0x61,
  0x8E, 0x38, 0xC3, 0x3C, 0xE0, 0x33, 0x9B, 0x8F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF1, 0xD8, 0xEC, 0x66, 0x00, 0x31, 0x8C, 0xE6, 0x31, 0x9C, 0xFF, 0xC0,
  0x38, 0xE7, 0x3C, 0xE7, 0x3D, 0xE7, 0xBC, 0xFD, 0x9F, 0xF7, 0xEC, 0xDD,
  0x9B, 0xB0, 0x39, 0x9C, 0xCE, 0xEF, 0x67, 0xB3, 0x79, 0xBD, 0xDC, 0xCE,
  0x67, 0x00, 0x1E, 0x3F, 0x73, 0x73, 0x67, 0x67, 0xE6, 0x6E, 0x7C, 0x78,
  0x3C, 0x7C, 0xDB, 0xB6, 0xEF, 0x9E, 0x70, 0xE1, 0x80, 0x1E, 0x3F, 0x73,
  0x73, 0x67, 0x67, 0xE6, 0x6E, 0x7C, 0x78, 0x1C, 0x1C, 0x3C, 0x7C, 0xDB,
  0xB7, 0xEF, 0x9F, 0x7E, 0xED, 0x98, 0x3E, 0xF9, 0xD3, 0x87, 0x87, 0x07,
  0x4E, 0xF9, 0xE0, 0xFF, 0xF3, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x00, 0x33,
  0x33, 0x77, 0x76, 0x66, 0x66, 0x66, 0xEE, 0x7C, 0x78, 0xE7, 0xEE, 0xEC,
  0xEC, 0xFC, 0xF8, 0xD8, 0xF0, 0xF0, 0xE0, 0xEC, 0xF9, 0x9B, 0x37, 0x6E,
  0xCD, 0xD9, 0xFF, 0x3F, 0xC7, 0x78, 0xEE, 0x1D, 0xC0, 0x3B, 0x8D, 0x87,
  0xC3, 0xC1, 0xC0, 0xE0, 0xF0, 0x7C, 0x7E, 0x73, 0x00, 0xEE, 0xD9, 0xF3,
  0xC7, 0x8E, 0x1C, 0x30, 0x61, 0xC0, 0x1F, 0x3F, 0x06, 0x0E, 0x1C, 0x18,
  0x38, 0x72, 0x7C, 0xFC, 0x1C, 0x63, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86,
  0x3C, 0xC6, 0x66, 0x66, 0x66, 0x23, 0x3C, 0x61, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xC6, 0x38, 0x08, 0x30, 0xF1, 0xE6, 0xDD, 0xB1, 0x80, 0xFF, 0xC0,
  0xED, 0x80, 0x36, 0xFD, 0xBB, 0x6E, 0xDD, 0xBF, 0x34, 0x30, 0x60, 0xC3,
  0xE7, 0xED, 0xDB, 0xB6, 0xED, 0xFB, 0xE0, 0x1D, 0xF6, 0x18, 0xE3, 0x8F,
  0x9E, 0x07, 0x06, 0x06, 0x36, 0x7E, 0x6E, 0x6C, 0xEC, 0xEC, 0xFC, 0x68,
  0x1D, 0xF6, 0xFF, 0xFB, 0x0F, 0x9E, 0x07, 0x0F, 0x0C, 0x1E, 0x1E, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0x36, 0xFD, 0xBB, 0x6E,
  0xDD, 0xBF, 0x3C, 0x19, 0xF3, 0xC0, 0x30, 0x60, 0xC3, 0xE7, 0xED, 0xDB,
  0x36, 0xED, 0x9B, 0x70, 0x33, 0x27, 0x66, 0x66, 0xEC, 0xC0, 0x0C, 0x30,
  0x87, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0xF3, 0x80, 0x30, 0x30, 0x30,
  0x77, 0x6E, 0x7C, 0x78, 0x78, 0xF8, 0xDC, 0xCC, 0x33, 0x37, 0x66, 0x66,
  0xEC, 0xC0, 0x6D, 0x9F, 0xF6, 0xED, 0xB7, 0x6D, 0xBB, 0x6D, 0xDB, 0x6E,
  0x6C, 0xFD, 0xBB, 0x66, 0xDD, 0xB3, 0x6E, 0x19, 0xF6, 0xDB, 0xEF, 0xBF,
  0x9E, 0x36, 0x3F, 0x37, 0x37, 0x36, 0x76, 0x7E, 0x7C, 0x60, 0x60, 0xE0,
  0x36, 0xFD, 0xBB, 0x6E, 0xDD, 0xBF, 0x3C, 0x18, 0x30, 0xE0, 0x6D, 0xE7,
  0x98, 0x63, 0x8C, 0x30, 0x3D, 0xE6, 0x1C, 0x38, 0xEF, 0xBC, 0x67, 0xFC,
  0xCC, 0xCE, 0xE0, 0x76, 0xCD, 0xBB, 0x66, 0xDD, 0xBF, 0x36, 0xCF, 0x7D,
  0xBE, 0xF3, 0xCE, 0x38, 0xDD, 0xEE, 0xFF, 0xDF, 0xEE, 0xF7, 0x73, 0xB9,
  0x98, 0x37, 0x3E, 0x3E, 0x1C, 0x1C, 0x3C, 0x7C, 0xEE, 0x33, 0x37, 0x36,
  0x3E, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0x70, 0xE0, 0x3E, 0x7C, 0x30, 0xC3,
  0x86, 0x1F, 0x7C, 0x1C, 0xF3, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x87, 0x1C,
  0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18, 0x71, 0x8C, 0x31, 0xCE,
  0x38, 0xF7, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 6, 4, 6, 1, -10 },
  { 9, 8, 10, 7, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 10, 10, 11, 1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 3, 4, 3, 1, -10 },
  { 55, 5, 12, 4, 0, -10 },
  { 63, 5, 12, 4, -1, -10 },
  { 71, 6, 7, 6, 1, -11 },
  { 77, 6, 6, 7, 1, -8 },
  { 82, 4, 4, 4, -1, -2 },
  { 84, 4, 2, 4, 0, -5 },
  { 85, 3, 2, 4, 0, -2 },
  { 86, 8, 10, 6, -1, -10 },
  { 96, 7, 10, 7, 0, -10 },
  { 105, 6, 10, 7, 1, -10 },
  { 113, 7, 10, 7, 0, -10 },
  { 122, 7, 10, 7, 0, -10 },
  { 131, 7, 10, 7, 0, -10 },
  { 140, 7, 10, 7, 0, -10 },
  { 149, 7, 10, 7, 0, -10 },
  { 158, 7, 10, 7, 0, -10 },
  { 167, 7, 10, 7, 0, -10 },
  { 176, 7, 10, 7, 0, -10 },
  { 185, 4, 8, 4, 0, -8 },
  { 189, 5, 10, 4, -1, -8 },
  { 196, 6, 7, 7, 1, -9 },
  { 202, 6, 5, 7, 1, -7 },
  { 206, 6, 7, 7, 1, -9 },
  { 212, 6, 10, 5, 0, -10 },
  { 220, 10, 11, 10, 0, -10 },
  { 234, 8, 10, 7, -1, -10 },
  { 244, 7, 10, 7, 0, -10 },
  { 253, 7, 10, 7, 0, -10 },
  { 262, 8, 10, 8, 0, -10 },
  { 272, 7, 10, 6, 0, -10 },
  { 281, 7, 10, 6, 0, -10 },
  { 290, 8, 10, 8, 0, -10 },
  { 300, 8, 10, 8, 0, -10 },
  { 310, 7, 10, 5, -1, -10 },
  { 319, 6, 13, 4, -2, -10 },
  { 329, 9, 10, 7, 0, -10 },
  { 341, 5, 10, 6, 0, -10 },
  { 348, 11, 10, 10, 0, -10 },
  { 362, 9, 10, 8, 0, -10 },
  { 374, 8, 10, 8, 0, -10 },
  { 384, 7, 10, 7, 0, -10 },
  { 393, 8, 12, 8, 0, -10 },
  { 405, 7, 10, 7, 0, -10 },
  { 414, 7, 10, 6, 0, -10 },
  { 423, 6, 10, 6, 1, -10 },
  { 431, 8, 10, 8, 0, -10 },
  { 441, 8, 10, 7, 1, -10 },
  { 451, 11, 10, 10, 1, -10 },
  { 465, 9, 10, 7, -1, -10 },
  { 477, 7, 10, 7, 1, -10 },
  { 486, 8, 10, 6, -1, -10 },
  { 496, 6, 12, 4, -1, -10 },
  { 505, 4, 10, 6, 1, -10 },
  { 510, 6, 12, 4, -1, -10 },
  { 519, 7, 7, 7, 0, -10 },
  { 526, 5, 2, 5, -1, 1 },
  { 528, 3, 3, 5, 2, -11 },
  { 530, 7, 8, 7, 0, -8 },
  { 537, 7, 11, 7, 0, -11 },
  { 547, 6, 8, 6, 0, -8 },
  { 553, 8, 11, 7, 0, -11 },
  { 564, 6, 8, 6, 0, -8 },
  { 570, 8, 14, 4, -2, -11 },
  { 584, 7, 11, 7, 0, -8 },
  { 594, 7, 11, 7, 0, -11 },
  { 604, 4, 11, 4, 0, -11 },
  { 610, 6, 14, 4, -2, -11 },
  { 621, 8, 11, 7, 0, -11 },
  { 632, 4, 11, 4, 0, -11 },
  { 638, 10, 8, 10, 0, -8 },
  { 648, 7, 8, 7, 0, -8 },
  { 655, 6, 8, 7, 0, -8 },
  { 661, 8, 11, 7, -1, -8 },
  { 672, 7, 11, 7, 0, -8 },
  { 682, 6, 8, 5, 0, -8 },
  { 688, 6, 8, 5, 0, -8 },
  { 694, 4, 9, 5, 1, -9 },
  { 699, 7, 8, 7, 0, -8 },
  { 706, 6, 8, 6, 1, -8 },
  { 712, 9, 8, 9, 1, -8 },
  { 721, 8, 8, 6, -1, -8 },
  { 729, 8, 11, 6, -1, -8 },
  { 740, 7, 8, 5, -1, -8 },
  { 747, 6, 12, 5, 0, -10 },
  { 756, 2, 14, 5, 2, -11 },
  { 760, 6, 12, 5, -1, -10 },
  { 769, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC14PT7B_H_
