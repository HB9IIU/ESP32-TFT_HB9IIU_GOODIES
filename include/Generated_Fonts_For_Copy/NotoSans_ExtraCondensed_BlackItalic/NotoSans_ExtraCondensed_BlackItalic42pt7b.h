#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x00, 0xC0, 0x00, 0x7F, 0xBF, 0xBF, 0x9F, 0xDF, 0xCF, 0xEF, 0xE7,
  0xE7, 0xE3, 0xF3, 0xF3, 0xFB, 0xF9, 0xFD, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF9, 0xF0, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFB, 0x18, 0x1F,
  0xB0, 0x81, 0xFB, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0D, 0xF8, 0x41, 0xDF, 0x07, 0x1B, 0xF0, 0xFD, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE,
  0x07, 0xC0, 0x3F, 0xFC, 0x1F, 0x00, 0xF9, 0xF0, 0xF8, 0x07, 0xC7, 0xC7,
  0xE0, 0x1F, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0xFC, 0x01, 0xF3, 0xE3, 0xE0,
  0x0F, 0x8F, 0x9F, 0x00, 0x3E, 0x3E, 0x7C, 0x00, 0xF9, 0xF3, 0xE3, 0xF3,
  0xF7, 0xCF, 0x9F, 0xE7, 0xFE, 0x7C, 0xFF, 0xDF, 0xFB, 0xF7, 0xFF, 0x7F,
  0xCF, 0x9F, 0x7C, 0xFE, 0x7E, 0xF9, 0xF0, 0x01, 0xF3, 0xE7, 0xC0, 0x0F,
  0x8F, 0x9F, 0x00, 0x3E, 0x7C, 0x7C, 0x01, 0xF1, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC7, 0xC0, 0x3E, 0x1F, 0x3E, 0x01, 0xF8, 0x7C, 0xF8, 0x07, 0xC1, 0xF7,
  0xE0, 0x3E, 0x07, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x9F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF9, 0xFC,
  0x1F, 0xF8, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF,
  0x1F, 0xDF, 0xFF, 0x8F, 0xE7, 0xFF, 0x87, 0xE3, 0xFF, 0xC7, 0xF0, 0xFF,
  0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0x9F, 0xF0, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x04, 0x3E, 0x07,
  0x1F, 0x03, 0xEF, 0x9D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x7C,
  0xFC, 0x1C, 0x7E, 0x06, 0x3C, 0x02, 0x08, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0x3F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC,
  0x10, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFE, 0x3F, 0x1F,
  0xCF, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFE, 0xFE,
  0x1F, 0xDF, 0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8,
  0x7F, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFD, 0xFC, 0x79, 0xFC, 0x33, 0xF8, 0x23, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x1F, 0xE0, 0x70,
  0x7F, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0x07, 0xF0, 0x20, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x80, 0x3F, 0x8C, 0x07, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0xF9,
  0xFC, 0x0F, 0xBF, 0x81, 0xF3, 0xF8, 0x3E, 0x3F, 0x83, 0xE3, 0xF8, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1C, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x80, 0x7F, 0x0C, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xEE, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x9E, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xE3, 0xF0,
  0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xEF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFF, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xF1, 0xFC, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xEF, 0xC0, 0x79, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0xF7, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x80, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00,
  0x20, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x60,
  0xFE, 0x20, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x7E, 0x1E, 0x0F, 0x8F, 0xFC,
  0xF8, 0xF8, 0xFF, 0xE7, 0xC7, 0x8F, 0xFF, 0x3E, 0x7C, 0xFC, 0xF9, 0xF3,
  0xC7, 0xC7, 0xCF, 0xBE, 0x7C, 0x3C, 0x79, 0xF3, 0xE3, 0xE3, 0xCF, 0x1F,
  0x1F, 0x1E, 0xF9, 0xF0, 0xF9, 0xF7, 0xCF, 0x87, 0x8F, 0xBE, 0x7C, 0x7C,
  0x79, 0xF3, 0xE3, 0xE7, 0xCF, 0x1F, 0x3F, 0x3C, 0x78, 0xFF, 0xFF, 0xE3,
  0xC7, 0xFF, 0xFE, 0x1F, 0x1F, 0xDF, 0xE0, 0xF8, 0x7C, 0x7E, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x07, 0xF0, 0x0F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x81,
  0xFD, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC1, 0x81, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x40, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x9F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0x03, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xF3, 0xFC, 0xFF, 0xCF, 0xF3, 0xFF, 0x3F,
  0x8F, 0xFC, 0xFE, 0x3F, 0xF3, 0xF8, 0xFF, 0x8F, 0xE4, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xDF, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE7, 0xFF,
  0x81, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x3F, 0x7E, 0xFB, 0xF8, 0x1F, 0xBF, 0xFD, 0xF8, 0x1F, 0xDF, 0xFD,
  0xFC, 0x0F, 0xEF, 0xFE, 0xFE, 0x07, 0xF7, 0xFF, 0x7F, 0x03, 0xF3, 0xFF,
  0x3F, 0x01, 0xF9, 0xFF, 0xBF, 0x81, 0xFC, 0xFF, 0x9F, 0xC0, 0xFE, 0x7F,
  0xCF, 0xE0, 0x7F, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0xE3, 0xF0, 0x1F, 0x8F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0xFE, 0x07, 0xF1,
  0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x83, 0xFF, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x3F, 0x81,
  0xFF, 0x87, 0xF0, 0x3F, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F, 0x81, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFC, 0xFE, 0x07, 0xFF, 0x9F, 0xC1, 0xFF, 0xF3, 0xF0, 0x3F,
  0xFE, 0x7E, 0x07, 0xEF, 0xEF, 0xC0, 0xFD, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF,
  0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x1F, 0xCF, 0xFF, 0x03, 0xF1,
  0xFF, 0xE0, 0x7E, 0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x7F, 0xE0,
  0x7F, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0,
  0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF,
  0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFF, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE7, 0xF8,
  0x7F, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F,
  0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x8E, 0x03, 0xFC, 0x08, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0x00, 0xFF, 0x06, 0x03, 0xFC,
  0x1F, 0x1F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x7F, 0x7F, 0x07, 0xE0, 0x7F, 0x7F, 0x07, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0,
  0xFE, 0x7E, 0x0F, 0xE1, 0xFC, 0x7E, 0x1F, 0xE1, 0xFC, 0x7E, 0x1F, 0xE1,
  0xFC, 0x7E, 0x1F, 0xE3, 0xF8, 0x7E, 0x3F, 0xE3, 0xF8, 0x7E, 0x3F, 0xE3,
  0xF8, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0x7F, 0xEF,
  0xE0, 0xFE, 0xFF, 0xEF, 0xE0, 0xFE, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0x80, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0x7F,
  0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x10, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x20, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E,
  0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x03, 0xF0, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x3F,
  0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x00, 0xC0, 0x00, 0x7F, 0x3F, 0x0F,
  0xF7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0x3E, 0x03, 0xE3, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF1, 0x80, 0x3F, 0xBF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFB, 0xFC, 0x1F, 0x8F, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0x18, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x04, 0x3F, 0xDE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x87, 0xF0, 0x1F, 0xDF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xE8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x8F, 0xE0, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xE7, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x20, 0x1F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF1, 0x80, 0x3F, 0xBF, 0x01, 0xFB, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0x07, 0xF0, 0xFE, 0x07,
  0xF1, 0xFC, 0x07, 0xF3, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x01, 0xC0, 0x60, 0x0F, 0xCF, 0xE3, 0xF0, 0x1F, 0xBF, 0xDF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFD, 0xFF, 0x7F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFC,
  0x1F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0x00, 0x01,
  0x80, 0x3F, 0x3F, 0x01, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE,
  0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8,
  0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3,
  0xF0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x7F, 0x0F, 0xDF, 0xC3, 0xF7,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFE, 0xFE, 0x3F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0xDF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xEF,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x3F, 0x07, 0xFB, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0x9F, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xE7, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0x81, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFE, 0x18, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x40, 0xFE, 0x3E, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE3, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xEC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFB, 0xF0, 0x3F, 0x3E, 0x00, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF0,
  0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7,
  0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x1F, 0xC3, 0xFB, 0xF1, 0xFE, 0x3F, 0x9F, 0x8F, 0xF1, 0xFC,
  0xFC, 0xFF, 0x8F, 0xC7, 0xE7, 0xFC, 0xFE, 0x3F, 0x3F, 0xE7, 0xE1, 0xFB,
  0xFF, 0x3F, 0x1F, 0xDF, 0xFB, 0xF8, 0xFE, 0xFF, 0xDF, 0x87, 0xFF, 0xBE,
  0xFC, 0x3F, 0x7D, 0xFF, 0xC1, 0xFB, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xF0,
  0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF,
  0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x1F, 0xDF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF9,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x81,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 13, 31, 11, 0, -30 },
  { 52, 17, 11, 19, 4, -30 },
  { 76, 24, 30, 22, 0, -30 },
  { 166, 20, 34, 20, 1, -32 },
  { 251, 30, 30, 33, 2, -30 },
  { 364, 25, 30, 25, 0, -30 },
  { 458, 9, 11, 10, 4, -30 },
  { 471, 15, 38, 12, 0, -31 },
  { 543, 15, 38, 12, -3, -31 },
  { 615, 17, 19, 19, 3, -32 },
  { 656, 18, 20, 21, 2, -25 },
  { 701, 10, 12, 11, -2, -6 },
  { 716, 12, 6, 13, 0, -14 },
  { 725, 8, 8, 11, 0, -7 },
  { 733, 23, 30, 17, -2, -30 },
  { 820, 19, 30, 20, 1, -30 },
  { 892, 16, 30, 20, 4, -30 },
  { 952, 21, 30, 20, -1, -30 },
  { 1031, 20, 30, 20, 0, -30 },
  { 1106, 20, 30, 20, 0, -30 },
  { 1181, 20, 30, 20, 1, -30 },
  { 1256, 20, 30, 20, 1, -30 },
  { 1331, 21, 30, 20, 1, -30 },
  { 1410, 20, 30, 20, 0, -30 },
  { 1485, 20, 30, 20, 0, -30 },
  { 1560, 11, 25, 11, 0, -24 },
  { 1595, 13, 30, 11, -2, -24 },
  { 1644, 18, 21, 21, 2, -26 },
  { 1692, 18, 15, 21, 2, -22 },
  { 1726, 18, 21, 21, 2, -26 },
  { 1774, 17, 31, 16, 1, -30 },
  { 1840, 29, 33, 30, 1, -30 },
  { 1960, 22, 30, 22, -2, -30 },
  { 2043, 22, 30, 22, 0, -30 },
  { 2126, 21, 30, 20, 1, -30 },
  { 2205, 23, 30, 23, 0, -30 },
  { 2292, 20, 30, 18, 0, -30 },
  { 2367, 20, 30, 17, 0, -30 },
  { 2442, 22, 30, 23, 2, -30 },
  { 2525, 25, 30, 24, 0, -30 },
  { 2619, 21, 30, 16, -2, -30 },
  { 2698, 20, 39, 12, -7, -30 },
  { 2796, 26, 30, 22, 0, -30 },
  { 2894, 15, 30, 17, 0, -30 },
  { 2951, 33, 30, 31, 0, -30 },
  { 3075, 27, 30, 25, 0, -30 },
  { 3177, 23, 30, 24, 1, -30 },
  { 3264, 22, 30, 20, 0, -30 },
  { 3347, 23, 37, 24, 1, -30 },
  { 3454, 22, 30, 21, 0, -30 },
  { 3537, 22, 30, 18, -1, -30 },
  { 3620, 18, 30, 18, 3, -30 },
  { 3688, 24, 30, 23, 1, -30 },
  { 3778, 22, 30, 22, 4, -30 },
  { 3861, 32, 30, 31, 3, -30 },
  { 3981, 26, 30, 21, -2, -30 },
  { 4079, 20, 30, 21, 4, -30 },
  { 4154, 23, 30, 18, -2, -30 },
  { 4241, 18, 38, 12, -2, -31 },
  { 4327, 10, 30, 17, 4, -30 },
  { 4365, 17, 38, 12, -3, -31 },
  { 4446, 21, 20, 20, -1, -30 },
  { 4499, 17, 5, 16, -4, 3 },
  { 4510, 9, 7, 14, 6, -32 },
  { 4518, 20, 24, 20, 1, -24 },
  { 4578, 21, 32, 20, -1, -32 },
  { 4662, 17, 24, 17, 1, -24 },
  { 4713, 22, 32, 20, 1, -32 },
  { 4801, 18, 24, 19, 1, -24 },
  { 4855, 23, 42, 13, -5, -32 },
  { 4976, 22, 34, 20, -1, -24 },
  { 5070, 21, 32, 21, -1, -32 },
  { 5154, 14, 33, 11, -1, -33 },
  { 5212, 18, 43, 11, -5, -33 },
  { 5309, 24, 32, 20, -1, -32 },
  { 5405, 14, 32, 11, -1, -32 },
  { 5461, 31, 24, 30, -1, -24 },
  { 5554, 21, 24, 21, -1, -24 },
  { 5617, 18, 24, 20, 1, -24 },
  { 5671, 23, 34, 20, -3, -24 },
  { 5769, 20, 34, 20, 1, -24 },
  { 5854, 18, 24, 15, -1, -24 },
  { 5908, 17, 24, 16, 0, -24 },
  { 5959, 14, 28, 14, 2, -28 },
  { 6008, 20, 23, 21, 1, -23 },
  { 6066, 19, 23, 19, 3, -23 },
  { 6121, 29, 23, 28, 2, -23 },
  { 6205, 23, 23, 19, -2, -23 },
  { 6272, 25, 33, 19, -3, -23 },
  { 6376, 20, 23, 16, -2, -23 },
  { 6434, 18, 37, 14, 0, -30 },
  { 6518, 6, 42, 16, 5, -32 },
  { 6550, 16, 37, 14, -2, -30 },
  { 6624, 18, 8, 21, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC42PT7B_H_
