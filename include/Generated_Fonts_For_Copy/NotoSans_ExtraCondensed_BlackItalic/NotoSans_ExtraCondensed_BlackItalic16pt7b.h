#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0xE7, 0x31, 0x80, 0x67, 0x38, 0x7E, 0xDD, 0xB7, 0x60,
  0x0F, 0x8D, 0x86, 0xCF, 0xF3, 0x61, 0xB3, 0xFD, 0xFE, 0x6C, 0x36, 0x36,
  0x00, 0x04, 0x1F, 0x3E, 0x3A, 0x38, 0x38, 0x1C, 0x1E, 0x9E, 0xFC, 0xFC,
  0x20, 0x20, 0x30, 0x4F, 0x33, 0x66, 0x6D, 0x8D, 0xB1, 0xED, 0xFF, 0x7A,
  0x6F, 0x1B, 0x63, 0x6C, 0xCF, 0xB8, 0xE0, 0x04, 0x07, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0x17, 0xD9, 0xFE, 0xEF, 0x3B, 0xCF, 0xF1, 0xFE, 0x76, 0x6E,
  0x0C, 0x63, 0x8C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x00,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x39, 0x8C, 0xE6, 0x73, 0x00, 0x18, 0xB3,
  0xFB, 0xF7, 0x9F, 0x92, 0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18,
  0x76, 0x6E, 0x7F, 0xFC, 0x7F, 0x80, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x18, 0x79, 0xFB, 0x7E,
  0xFD, 0xB3, 0x6E, 0xDD, 0xB3, 0xE7, 0x80, 0x1E, 0x79, 0xF7, 0xE5, 0xC3,
  0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x0C, 0x3E, 0x3F, 0x26, 0x06, 0x0E, 0x1C,
  0x38, 0x70, 0x60, 0xFC, 0xFC, 0x0C, 0x3E, 0x3F, 0x07, 0x06, 0x3C, 0x3C,
  0x0E, 0x0E, 0x9E, 0xFC, 0xF8, 0x07, 0x0E, 0x1E, 0x1E, 0x3E, 0x6C, 0xCC,
  0xFE, 0xFE, 0x1C, 0x18, 0x1F, 0x3E, 0x30, 0x30, 0x7C, 0x7E, 0x0E, 0x0E,
  0x9C, 0xFC, 0xF8, 0x0E, 0x7D, 0xFB, 0x8E, 0x9F, 0xBF, 0x6E, 0xDD, 0xBB,
  0xE7, 0x80, 0x3F, 0x3F, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0xE0, 0x0C, 0x1E, 0x3F, 0x37, 0x36, 0x3C, 0x3C, 0x7E, 0xEE, 0xEE, 0xFC,
  0x78, 0x0C, 0x3E, 0x3E, 0x77, 0x77, 0x76, 0x7E, 0x7E, 0x0E, 0x1C, 0xF8,
  0xF0, 0x37, 0x70, 0x00, 0x6E, 0xE0, 0x19, 0xCE, 0x00, 0x00, 0x0E, 0x63,
  0x38, 0x02, 0x1C, 0xFF, 0x8E, 0x0F, 0x87, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x81, 0x83, 0xC1, 0xF1, 0xEF, 0x38, 0x40, 0x08, 0xFD, 0xFA, 0x70,
  0xC3, 0x0C, 0x38, 0x00, 0xC1, 0x87, 0x00, 0x03, 0x01, 0xF8, 0x61, 0x99,
  0xB6, 0xFA, 0xDB, 0x56, 0xDE, 0xDB, 0xDB, 0x5B, 0xB9, 0x00, 0x39, 0x83,
  0xF0, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xFE, 0x7F, 0x7F, 0xB9,
  0xF8, 0xE0, 0x3F, 0x3F, 0x33, 0x37, 0x7E, 0x7E, 0x76, 0x67, 0xEE, 0xFE,
  0xFC, 0x0C, 0x3F, 0x7E, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE8, 0xF8,
  0x78, 0x3F, 0x1F, 0x8C, 0xE6, 0x77, 0x3B, 0x99, 0xDC, 0xCE, 0xEE, 0x7E,
  0x3E, 0x00, 0x3F, 0x3E, 0x30, 0x30, 0x7C, 0x7C, 0x70, 0x60, 0xE4, 0xF8,
  0xF8, 0x3F, 0x3E, 0x30, 0x30, 0x7C, 0x7C, 0x7C, 0x60, 0xE0, 0xE0, 0xE0,
  0x04, 0x3F, 0x7F, 0x70, 0xE0, 0xEF, 0xEE, 0xDE, 0xCE, 0xEE, 0xFC, 0x7C,
  0x39, 0xCE, 0x63, 0x38, 0xCE, 0x7F, 0x9F, 0xC7, 0x31, 0x9C, 0xE7, 0x39,
  0xCE, 0x60, 0x1F, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x7C,
  0xFC, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x78, 0x70, 0xE0, 0x3B, 0xCE, 0xE3, 0x70, 0xF8, 0x7E, 0x1F, 0x07,
  0xE1, 0xB8, 0xEE, 0x3B, 0x8E, 0xE0, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x18,
  0xE3, 0xFF, 0x80, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0x7B, 0xE7, 0xDE, 0x3F,
  0xB1, 0xBF, 0x8D, 0xFC, 0xEE, 0xE7, 0x76, 0x3B, 0x70, 0x38, 0xCF, 0x73,
  0xDC, 0xF7, 0x7D, 0x9F, 0x66, 0xF9, 0xBE, 0xE7, 0x39, 0xCE, 0x70, 0x0C,
  0x3E, 0x7F, 0x77, 0xE7, 0xE7, 0xE7, 0xC7, 0xCE, 0xEE, 0xFC, 0x78, 0x3F,
  0x3F, 0x37, 0x37, 0x77, 0x7E, 0x7C, 0x60, 0xE0, 0xE0, 0xE0, 0x0C, 0x3E,
  0x7F, 0x77, 0xE7, 0xE7, 0xE7, 0xC7, 0xCE, 0xEE, 0xFC, 0x78, 0x38, 0x1C,
  0x1C, 0x3F, 0x3F, 0x37, 0x37, 0x77, 0x7E, 0x7C, 0x6C, 0xEE, 0xEE, 0xEE,
  0x0C, 0x3F, 0x3E, 0x72, 0x70, 0x78, 0x3C, 0x1C, 0x0C, 0xDC, 0xFC, 0xF8,
  0x7F, 0xFC, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x80, 0x73, 0x77,
  0x67, 0xE7, 0xE6, 0xEE, 0xEE, 0xCE, 0xCC, 0xFC, 0xF8, 0xE3, 0xB3, 0x99,
  0xCD, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xE7, 0x7E,
  0x67, 0xEE, 0x6E, 0xEE, 0xFE, 0xEF, 0xEC, 0xFF, 0xCF, 0x78, 0xF7, 0x8F,
  0x78, 0xE7, 0x00, 0x1D, 0xC7, 0xE1, 0xF0, 0x7C, 0x0E, 0x03, 0x81, 0xE0,
  0xF8, 0x37, 0x1D, 0xCE, 0x70, 0xE7, 0x6E, 0x7E, 0x7C, 0x78, 0x78, 0x30,
  0x70, 0x70, 0x70, 0x60, 0x1F, 0x9F, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x3F, 0x3F, 0x80, 0x1E, 0x3C, 0x60, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0xE1, 0x83, 0x06, 0x1E, 0x3C, 0x00, 0xDB, 0x6D, 0xBF, 0x6D, 0xB0,
  0x1C, 0xF0, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x33, 0xCE, 0x00,
  0x0C, 0x1C, 0x1E, 0x36, 0x76, 0x66, 0xC7, 0x7F, 0xFC, 0xE7, 0x3B, 0x3F,
  0x77, 0x66, 0xE6, 0xEE, 0xEE, 0xFC, 0x6C, 0x38, 0x38, 0x30, 0x3E, 0x7E,
  0x77, 0x77, 0x66, 0x66, 0xEE, 0xFC, 0xDC, 0x1E, 0x79, 0xD3, 0x0E, 0x1C,
  0x39, 0x7C, 0x78, 0x03, 0x81, 0x80, 0xC7, 0xE3, 0xF3, 0xB9, 0x99, 0xCC,
  0xEE, 0x77, 0x3F, 0x0F, 0x80, 0x1C, 0x7D, 0xDB, 0x7F, 0xDC, 0x39, 0x7E,
  0x7C, 0x07, 0x87, 0x83, 0x81, 0xE1, 0xF0, 0xE0, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x87, 0x83, 0xC1, 0xC0, 0x3B, 0x3F, 0x77, 0x66, 0xE6,
  0xEE, 0xEE, 0xFC, 0x7C, 0x1C, 0x9C, 0xF8, 0xF0, 0x38, 0x38, 0x30, 0x3E,
  0x7F, 0x77, 0x76, 0x66, 0x6E, 0xEE, 0xEE, 0xCC, 0x39, 0xC0, 0x67, 0x39,
  0xCC, 0x67, 0x39, 0x80, 0x0E, 0x1C, 0x00, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0x83, 0x1E, 0x3C, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x77, 0x73,
  0xF1, 0xF0, 0xF8, 0x7C, 0x76, 0x3B, 0x99, 0xC0, 0x39, 0xCC, 0x67, 0x39,
  0xCC, 0x67, 0x39, 0x80, 0x3E, 0xEF, 0xFD, 0xDD, 0xBB, 0x36, 0x6E, 0xDD,
  0xFB, 0xBF, 0x66, 0xCD, 0xC0, 0x3E, 0x7F, 0x77, 0x76, 0x66, 0x6E, 0xEE,
  0xEE, 0xCC, 0x1C, 0x7D, 0xDB, 0x3E, 0x7D, 0xFB, 0xBE, 0x78, 0x1F, 0x1F,
  0x8E, 0xE7, 0x73, 0x31, 0x99, 0xDC, 0xFC, 0x6E, 0x30, 0x38, 0x1C, 0x0E,
  0x00, 0x3B, 0x3F, 0x77, 0x66, 0xE6, 0xEE, 0xEE, 0xFC, 0x7C, 0x1C, 0x1C,
  0x1C, 0x18, 0x3D, 0xF7, 0xDC, 0x61, 0x8E, 0x38, 0xC0, 0x3D, 0xF7, 0x5C,
  0x78, 0xE9, 0xBE, 0xF0, 0x31, 0x9F, 0xFE, 0x73, 0x98, 0xC7, 0xBC, 0x37,
  0x77, 0x77, 0x76, 0x66, 0x6E, 0xEE, 0xFE, 0x7C, 0xEF, 0xDF, 0xB7, 0xED,
  0x9F, 0x3C, 0x78, 0xE0, 0xEE, 0xFB, 0xDB, 0x7F, 0x6F, 0xCF, 0x59, 0xFF,
  0x3F, 0xC7, 0x78, 0xEE, 0x00, 0x3B, 0x9D, 0x87, 0xC3, 0xC1, 0xC1, 0xF0,
  0xF8, 0xFC, 0xE6, 0x00, 0x3B, 0x9D, 0xCE, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0,
  0x78, 0x18, 0x1C, 0x3C, 0x1E, 0x0E, 0x00, 0x3F, 0x3F, 0x0E, 0x0C, 0x1C,
  0x38, 0x70, 0x7C, 0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x8E, 0x30, 0x78, 0x70,
  0xE1, 0x83, 0x87, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF1, 0xC7,
  0x18, 0x70, 0xCF, 0x38, 0xC7, 0x3C, 0xE2, 0x00, 0xF3, 0xFE, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 8, 0, -11 },
  { 25, 8, 13, 8, 0, -12 },
  { 38, 11, 12, 13, 1, -12 },
  { 55, 10, 12, 10, 0, -12 },
  { 70, 4, 4, 4, 1, -11 },
  { 72, 6, 15, 5, 0, -12 },
  { 84, 5, 15, 5, -1, -12 },
  { 94, 7, 7, 7, 1, -12 },
  { 101, 7, 8, 8, 1, -10 },
  { 108, 4, 4, 4, -1, -2 },
  { 110, 5, 3, 5, 0, -6 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 9, 12, 6, -1, -12 },
  { 128, 7, 12, 8, 1, -12 },
  { 139, 7, 11, 8, 1, -11 },
  { 149, 8, 12, 8, 0, -12 },
  { 161, 8, 12, 8, 0, -12 },
  { 173, 8, 11, 8, 0, -11 },
  { 184, 8, 11, 8, 0, -11 },
  { 195, 7, 12, 8, 1, -12 },
  { 206, 8, 11, 8, 0, -11 },
  { 217, 8, 12, 8, 0, -12 },
  { 229, 8, 12, 8, 0, -12 },
  { 241, 4, 9, 4, 0, -9 },
  { 246, 5, 11, 4, -1, -9 },
  { 253, 7, 8, 8, 1, -10 },
  { 260, 7, 5, 8, 1, -8 },
  { 265, 7, 8, 8, 1, -10 },
  { 272, 7, 12, 6, 0, -12 },
  { 283, 11, 13, 11, 0, -12 },
  { 301, 9, 11, 9, -1, -11 },
  { 314, 8, 11, 8, 0, -11 },
  { 325, 8, 12, 8, 1, -12 },
  { 337, 9, 11, 9, 0, -11 },
  { 350, 8, 11, 7, 0, -11 },
  { 361, 8, 11, 7, 0, -11 },
  { 372, 8, 12, 9, 1, -12 },
  { 384, 10, 11, 9, 0, -11 },
  { 398, 8, 11, 6, -1, -11 },
  { 409, 8, 15, 4, -3, -11 },
  { 424, 10, 11, 8, 0, -11 },
  { 438, 6, 11, 6, 0, -11 },
  { 447, 13, 11, 12, 0, -11 },
  { 465, 10, 11, 10, 0, -11 },
  { 479, 8, 12, 9, 1, -12 },
  { 491, 8, 11, 8, 0, -11 },
  { 502, 8, 15, 9, 1, -12 },
  { 517, 8, 11, 8, 0, -11 },
  { 528, 8, 12, 7, 0, -12 },
  { 540, 7, 11, 7, 1, -11 },
  { 550, 8, 11, 9, 1, -11 },
  { 561, 9, 11, 8, 1, -11 },
  { 574, 12, 11, 12, 1, -11 },
  { 591, 10, 11, 8, -1, -11 },
  { 605, 8, 11, 8, 1, -11 },
  { 616, 9, 11, 7, -1, -11 },
  { 629, 7, 15, 5, -1, -12 },
  { 643, 3, 12, 6, 2, -12 },
  { 648, 6, 15, 5, -1, -12 },
  { 660, 8, 7, 7, 0, -11 },
  { 667, 7, 2, 6, -2, 1 },
  { 669, 4, 2, 5, 2, -12 },
  { 670, 8, 9, 8, 0, -9 },
  { 679, 8, 12, 8, 0, -12 },
  { 691, 7, 9, 6, 0, -9 },
  { 699, 9, 12, 8, 0, -12 },
  { 713, 7, 9, 7, 0, -9 },
  { 721, 9, 16, 5, -2, -12 },
  { 739, 8, 13, 8, 0, -9 },
  { 752, 8, 12, 8, 0, -12 },
  { 764, 5, 12, 4, 0, -12 },
  { 772, 7, 16, 4, -2, -12 },
  { 786, 9, 12, 8, 0, -12 },
  { 800, 5, 12, 4, 0, -12 },
  { 808, 11, 9, 12, 0, -9 },
  { 821, 8, 9, 8, 0, -9 },
  { 830, 7, 9, 8, 0, -9 },
  { 838, 9, 13, 8, -1, -9 },
  { 853, 8, 13, 8, 0, -9 },
  { 866, 6, 9, 6, 0, -9 },
  { 873, 6, 9, 6, 0, -9 },
  { 880, 5, 11, 5, 1, -11 },
  { 887, 8, 9, 8, 0, -9 },
  { 896, 7, 9, 7, 1, -9 },
  { 904, 11, 9, 11, 1, -9 },
  { 917, 9, 9, 7, -1, -9 },
  { 928, 9, 13, 7, -1, -9 },
  { 943, 8, 9, 6, -1, -9 },
  { 952, 7, 14, 6, 0, -11 },
  { 965, 2, 16, 6, 2, -12 },
  { 969, 6, 14, 6, -1, -11 },
  { 980, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC16PT7B_H_
