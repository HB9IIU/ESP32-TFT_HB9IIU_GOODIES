#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB,
  0xDF, 0xC0, 0x0F, 0xFC, 0xE0, 0xF0, 0x03, 0xFE, 0x38, 0x18, 0x00, 0xFF,
  0x9E, 0x02, 0x00, 0x3F, 0xE7, 0x80, 0x00, 0x0F, 0xFD, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3B, 0xFF, 0x00, 0x00, 0x1E, 0xFF, 0xC0, 0x20, 0x07, 0x9F, 0xF0, 0x0C,
  0x01, 0xE7, 0xFC, 0x03, 0xC0, 0x73, 0xFF, 0x01, 0xFC, 0x1C, 0xFF, 0xC0,
  0x7F, 0xCF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0x01, 0xF0,
  0x3F, 0xC3, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF,
  0xE3, 0xFE, 0xFF, 0x8F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F,
  0xFF, 0xBF, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x8F,
  0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xF3,
  0xFE, 0x7F, 0xCF, 0xFF, 0x87, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x83, 0xFE,
  0x3F, 0xC3, 0xFC, 0x0F, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xCF, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x60,
  0x7F, 0xC0, 0x07, 0x83, 0xFE, 0x00, 0x3F, 0x1F, 0xF0, 0x11, 0xFE, 0xFF,
  0x03, 0x9F, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07,
  0xFC, 0x7F, 0xE0, 0x1F, 0xC3, 0xFF, 0x80, 0x7C, 0x1F, 0xF0, 0x01, 0xE0,
  0x7E, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF,
  0x3F, 0xF8, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0,
  0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x87,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF,
  0x81, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x80,
  0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xE0,
  0xFF, 0x3F, 0xF8, 0x0F, 0xC7, 0xFF, 0x01, 0xF1, 0xFF, 0xE0, 0x1C, 0x3F,
  0xFC, 0x01, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x1F, 0xFE, 0x00, 0x3E, 0x03,
  0xFF, 0xC0, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0xF0, 0x1F, 0xFF, 0x00,
  0x30, 0x07, 0xFF, 0x80, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x08, 0x00, 0x0F, 0xFF, 0x83, 0x00, 0x03, 0xFF, 0xE0, 0xF0, 0x01,
  0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0x3F,
  0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0xE0, 0x01, 0xFE,
  0x3F, 0xFC, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xF0,
  0x07, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x04, 0x00, 0x0F, 0xFF, 0x83, 0x80, 0x07, 0xFF, 0xC1, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xE0,
  0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x3F, 0xF8,
  0x01, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFB, 0xFF, 0xF0, 0x78, 0x0F, 0xFF, 0x06, 0x00, 0xFF, 0xE0,
  0x40, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xF8, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x7F, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0xFE, 0x1F,
  0xE0, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0xFE, 0x1F,
  0xF1, 0xFF, 0x8F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F,
  0xFF, 0xBF, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFE, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F,
  0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x40, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x04, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x77, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x3F, 0xF8, 0x00, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xBF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFD,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x9F, 0xFD,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0xFF, 0xF1, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xFF,
  0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF,
  0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xFC,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF,
  0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xE0,
  0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0xFF, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x80,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC,
  0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xE0, 0x03, 0xFF,
  0xC0, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0xF0, 0x0E,
  0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC8, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE,
  0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x9F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFC,
  0x01, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x9F,
  0xFC, 0x03, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFC, 0x7F,
  0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xF8, 0x07, 0xFC,
  0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0xC0, 0x60, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x08, 0x0F, 0xFF, 0x01,
  0xC0, 0x7F, 0xFC, 0x3E, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xF0,
  0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xDF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x1F, 0xFE, 0x00, 0x70, 0x1F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x84, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x83,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xBF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x0C, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x83,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xE3, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xFE, 0x01,
  0xFF, 0xBF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x1F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xC1, 0xFF,
  0xE7, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF3,
  0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xDF, 0xFC, 0x03,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x0E, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x0F, 0xFE, 0x01, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0xFF, 0xF0, 0xE0, 0x0F, 0xFF, 0x0F,
  0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x18,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80,
  0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFC,
  0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFC,
  0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0xFC,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFD,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xF7, 0xFD,
  0xFF, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC,
  0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x23, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x02, 0x7F, 0xFE, 0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE4, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x01, 0xFC,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 22, 51, 18, 0, -50 },
  { 142, 30, 18, 32, 6, -50 },
  { 210, 39, 50, 37, 0, -50 },
  { 454, 34, 57, 33, 1, -53 },
  { 697, 50, 52, 55, 4, -51 },
  { 1022, 42, 52, 42, 0, -51 },
  { 1295, 15, 18, 17, 6, -50 },
  { 1329, 25, 62, 20, 1, -51 },
  { 1523, 25, 62, 20, -6, -51 },
  { 1717, 29, 33, 31, 5, -54 },
  { 1837, 30, 34, 35, 3, -42 },
  { 1965, 17, 20, 18, -4, -10 },
  { 2008, 20, 11, 21, 1, -24 },
  { 2036, 13, 13, 18, 0, -12 },
  { 2058, 38, 52, 28, -4, -51 },
  { 2305, 31, 52, 33, 2, -51 },
  { 2507, 27, 50, 33, 6, -50 },
  { 2676, 35, 51, 33, -2, -51 },
  { 2900, 34, 52, 33, 0, -51 },
  { 3121, 35, 50, 33, -1, -50 },
  { 3340, 33, 51, 33, 1, -50 },
  { 3551, 33, 52, 33, 2, -51 },
  { 3766, 35, 50, 33, 2, -50 },
  { 3985, 33, 52, 33, 1, -51 },
  { 4200, 32, 52, 33, 1, -51 },
  { 4408, 19, 40, 19, 0, -39 },
  { 4503, 23, 49, 19, -4, -39 },
  { 4644, 30, 35, 35, 3, -43 },
  { 4776, 30, 25, 35, 3, -37 },
  { 4870, 31, 35, 35, 3, -43 },
  { 5006, 28, 52, 26, 2, -51 },
  { 5188, 48, 56, 49, 2, -51 },
  { 5524, 37, 50, 37, -4, -50 },
  { 5756, 37, 50, 36, 0, -50 },
  { 5988, 35, 52, 33, 2, -51 },
  { 6216, 38, 50, 38, 0, -50 },
  { 6454, 33, 50, 29, 0, -50 },
  { 6661, 33, 50, 28, 0, -50 },
  { 6868, 38, 52, 38, 3, -51 },
  { 7115, 42, 50, 39, 0, -50 },
  { 7378, 34, 50, 26, -3, -50 },
  { 7591, 33, 66, 19, -11, -50 },
  { 7864, 43, 50, 36, 0, -50 },
  { 8133, 25, 50, 28, 0, -50 },
  { 8290, 55, 50, 52, 0, -50 },
  { 8634, 45, 50, 42, 0, -50 },
  { 8916, 38, 52, 40, 2, -51 },
  { 9163, 36, 50, 34, 0, -50 },
  { 9388, 38, 63, 40, 2, -51 },
  { 9688, 36, 50, 35, 0, -50 },
  { 9913, 35, 52, 30, -1, -51 },
  { 10141, 30, 50, 30, 5, -50 },
  { 10329, 39, 51, 38, 2, -50 },
  { 10578, 36, 50, 36, 7, -50 },
  { 10803, 54, 50, 52, 5, -50 },
  { 11141, 44, 50, 35, -4, -50 },
  { 11416, 34, 50, 34, 7, -50 },
  { 11629, 39, 50, 31, -3, -50 },
  { 11873, 30, 63, 20, -4, -51 },
  { 12110, 16, 52, 28, 7, -51 },
  { 12214, 29, 63, 20, -5, -51 },
  { 12443, 34, 33, 33, -1, -50 },
  { 12584, 29, 8, 27, -7, 5 },
  { 12613, 15, 12, 23, 10, -54 },
  { 12636, 34, 40, 34, 1, -39 },
  { 12806, 34, 54, 34, -1, -53 },
  { 13036, 29, 40, 28, 1, -39 },
  { 13181, 37, 54, 34, 1, -53 },
  { 13431, 31, 40, 32, 1, -39 },
  { 13586, 38, 71, 22, -8, -54 },
  { 13924, 37, 56, 34, -2, -39 },
  { 14183, 34, 53, 34, -1, -53 },
  { 14409, 22, 54, 18, -1, -54 },
  { 14558, 30, 71, 18, -9, -54 },
  { 14825, 39, 53, 34, -1, -53 },
  { 15084, 23, 53, 18, -1, -53 },
  { 15237, 51, 39, 51, -1, -39 },
  { 15486, 34, 39, 34, -1, -39 },
  { 15652, 31, 40, 34, 1, -39 },
  { 15807, 37, 56, 34, -4, -39 },
  { 16066, 34, 56, 34, 1, -39 },
  { 16304, 29, 39, 25, -1, -39 },
  { 16446, 28, 40, 27, 0, -39 },
  { 16586, 23, 47, 24, 3, -46 },
  { 16722, 34, 40, 34, 1, -39 },
  { 16892, 32, 39, 32, 4, -39 },
  { 17048, 48, 39, 47, 3, -39 },
  { 17282, 40, 39, 32, -4, -39 },
  { 17477, 40, 56, 32, -4, -39 },
  { 17757, 33, 39, 27, -3, -39 },
  { 17918, 29, 61, 24, 0, -50 },
  { 18140, 10, 70, 27, 9, -54 },
  { 18228, 28, 61, 24, -4, -50 },
  { 18442, 31, 13, 35, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC70PT7B_H_
