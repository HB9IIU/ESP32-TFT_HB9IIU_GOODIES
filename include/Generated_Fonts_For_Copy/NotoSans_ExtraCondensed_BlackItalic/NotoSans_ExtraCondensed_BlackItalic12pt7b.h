#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x0C, 0xC0, 0x7E, 0xF7, 0xA0, 0x16, 0x28, 0xF3,
  0xF2, 0x9F, 0xBF, 0x28, 0xF0, 0x10, 0xF7, 0x9C, 0x38, 0x6B, 0xBE, 0x60,
  0x80, 0x62, 0xE4, 0xBC, 0xA8, 0xFF, 0xD5, 0x3D, 0x2F, 0x66, 0x18, 0x78,
  0xB1, 0xC3, 0x6F, 0xF7, 0x7E, 0xFE, 0x7B, 0x60, 0x13, 0x66, 0x4C, 0xCC,
  0xCC, 0xC0, 0x31, 0x11, 0x33, 0x32, 0x66, 0xC0, 0x37, 0x7F, 0xE7, 0x00,
  0x63, 0x3F, 0xF6, 0x30, 0x6D, 0x60, 0xFE, 0xF0, 0x06, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x30, 0xC0, 0x18, 0xF6, 0xDB, 0x6F, 0x6D, 0xBE, 0x70, 0x19,
  0x9D, 0xE3, 0x19, 0x8C, 0x60, 0x19, 0xF4, 0xC6, 0x18, 0xC6, 0x3E, 0xF0,
  0x39, 0xF4, 0xC6, 0x31, 0xE1, 0xBE, 0xF0, 0x0C, 0x71, 0x8E, 0x7B, 0x6F,
  0x8C, 0x30, 0x3C, 0xF2, 0x1C, 0x78, 0x61, 0xBE, 0xF0, 0x0C, 0xF7, 0x1E,
  0x7B, 0xED, 0xBE, 0x70, 0x3D, 0xF0, 0xC6, 0x18, 0xC3, 0x18, 0xE0, 0x18,
  0xF6, 0xDE, 0x31, 0xED, 0xB6, 0x70, 0x18, 0xE6, 0xDB, 0x7D, 0xE1, 0xBC,
  0xE0, 0x2D, 0x01, 0xB0, 0x13, 0x20, 0x06, 0x64, 0xC0, 0x0C, 0xFE, 0x1E,
  0x1C, 0x10, 0xF8, 0x3F, 0xF0, 0x87, 0x0E, 0xEC, 0x40, 0x33, 0xD6, 0x33,
  0x30, 0x0C, 0xC0, 0x0E, 0x1D, 0x89, 0x4B, 0xF5, 0x57, 0xAB, 0xFD, 0xAC,
  0x44, 0x1E, 0x00, 0x0E, 0x1C, 0x78, 0xB3, 0x66, 0xDF, 0xB3, 0xE6, 0x38,
  0xF6, 0xDB, 0x79, 0xFC, 0xFE, 0xF0, 0x1C, 0xF7, 0x58, 0x63, 0x8E, 0x1E,
  0x78, 0x30, 0x79, 0xB3, 0x76, 0xCD, 0xB3, 0x7C, 0xF0, 0x3C, 0xE6, 0x18,
  0x79, 0x8C, 0x3C, 0xF0, 0x3C, 0xE6, 0x18, 0x79, 0xCC, 0x30, 0xC0, 0x0C,
  0x7D, 0xCB, 0x06, 0xDF, 0xBB, 0x3E, 0x78, 0x36, 0x6D, 0x9B, 0x37, 0xCD,
  0xB3, 0x66, 0xDC, 0x7B, 0xCC, 0x67, 0x31, 0x8C, 0xF0, 0x0C, 0x31, 0x86,
  0x18, 0x63, 0x8C, 0x30, 0xCE, 0x30, 0x36, 0x7D, 0xB3, 0xC7, 0x8F, 0x36,
  0x6C, 0xDC, 0x33, 0x66, 0x66, 0xCF, 0xF0, 0x31, 0x99, 0xDC, 0xEE, 0xF7,
  0x7B, 0xFB, 0x7D, 0xB6, 0xDB, 0x00, 0x33, 0x33, 0x76, 0x7E, 0x7E, 0x7E,
  0xDC, 0xDC, 0xCC, 0x1C, 0x7D, 0xDB, 0x36, 0x7D, 0xFB, 0x3E, 0x78, 0x38,
  0xF6, 0xDB, 0x7D, 0xEC, 0x30, 0xC0, 0x1C, 0x7D, 0xDB, 0x36, 0x7D, 0xFB,
  0x3E, 0x78, 0x30, 0x60, 0x38, 0xF6, 0xDB, 0x7D, 0xED, 0xB6, 0xDC, 0x19,
  0xF6, 0x98, 0x70, 0xE1, 0xBE, 0xF0, 0xFF, 0xD8, 0xC6, 0x33, 0x18, 0xC0,
  0x36, 0x6D, 0x9B, 0x66, 0xCD, 0xB3, 0x7C, 0x78, 0xCF, 0x3D, 0xB6, 0xDB,
  0xCF, 0x38, 0xE0, 0xC9, 0xEC, 0xF6, 0xDB, 0x6F, 0xA7, 0x73, 0xB9, 0xD8,
  0xDC, 0x00, 0x33, 0x36, 0x1E, 0x1C, 0x18, 0x1C, 0x3C, 0x6C, 0xEC, 0xCF,
  0x6D, 0x9C, 0x71, 0x86, 0x18, 0xC0, 0x7D, 0xF1, 0x86, 0x31, 0x86, 0x3E,
  0xF0, 0x19, 0xCC, 0x63, 0x11, 0x8C, 0x62, 0x38, 0xDB, 0x24, 0xDB, 0x60,
  0x39, 0xC6, 0x23, 0x18, 0xC6, 0x23, 0x38, 0x10, 0x63, 0x9E, 0x6B, 0x30,
  0xF8, 0xD0, 0x3D, 0xF6, 0xF6, 0xDB, 0xEF, 0x80, 0x31, 0x87, 0x9F, 0x6D,
  0x3D, 0xBE, 0xF0, 0x3B, 0xD9, 0x8C, 0x79, 0xC0, 0x0E, 0x18, 0xF3, 0xE6,
  0xDB, 0x36, 0x7C, 0xF8, 0x3B, 0xDB, 0xFC, 0x69, 0xC0, 0x1C, 0x63, 0x9E,
  0x30, 0xC2, 0x18, 0x61, 0x8E, 0x30, 0x3D, 0xF6, 0xF6, 0xDB, 0xEF, 0x84,
  0xF3, 0x80, 0x31, 0x87, 0x9F, 0x6D, 0xED, 0xB6, 0xD8, 0x32, 0x66, 0x66,
  0xCC, 0xC0, 0x0C, 0x21, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xCE, 0x38, 0x31,
  0x86, 0xDB, 0x79, 0xCF, 0xB6, 0xD8, 0x36, 0x66, 0x66, 0xCC, 0xC0, 0x7B,
  0x3F, 0xDB, 0xCF, 0x6D, 0xB6, 0xDB, 0x6C, 0x79, 0xF6, 0xDE, 0xDB, 0x6D,
  0x80, 0x39, 0xE6, 0xF2, 0xDB, 0xE7, 0x00, 0x3C, 0x7C, 0xD9, 0x36, 0xCF,
  0x9E, 0x30, 0x41, 0x80, 0x3D, 0xF6, 0xF6, 0xDB, 0xEF, 0x84, 0x30, 0xC0,
  0x7B, 0xD8, 0xCC, 0x63, 0x00, 0x33, 0xD8, 0xE3, 0x7B, 0x80, 0x31, 0xDC,
  0xC6, 0x33, 0x8C, 0x6D, 0xB6, 0xD6, 0xDB, 0xEF, 0x80, 0xDE, 0xFD, 0xEE,
  0x73, 0x00, 0xDB, 0xFE, 0xFE, 0xBE, 0xFC, 0xDC, 0xD8, 0x36, 0x78, 0xF0,
  0xC3, 0x8F, 0x3B, 0x00, 0x36, 0x6C, 0xF1, 0xE3, 0x87, 0x0C, 0x18, 0x61,
  0x80, 0x3C, 0xF1, 0x8C, 0x31, 0xEF, 0x80, 0x09, 0xCC, 0x66, 0x61, 0x8C,
  0x63, 0x18, 0xFF, 0xFF, 0xFF, 0x21, 0x86, 0x63, 0x0C, 0xE4, 0x67, 0x30,
  0xFE, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 7, 9, 6, 0, -9 },
  { 17, 6, 10, 6, 0, -9 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 3, 4, 3, 1, -9 },
  { 44, 4, 11, 3, 0, -9 },
  { 50, 4, 11, 3, -1, -9 },
  { 56, 5, 5, 5, 1, -9 },
  { 60, 5, 6, 6, 1, -7 },
  { 64, 3, 4, 3, -1, -2 },
  { 66, 4, 2, 4, 0, -4 },
  { 67, 2, 2, 3, 0, -2 },
  { 68, 7, 9, 5, -1, -9 },
  { 76, 6, 9, 6, 0, -9 },
  { 83, 5, 9, 6, 1, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 6, 9, 6, 0, -9 },
  { 124, 6, 9, 6, 0, -9 },
  { 131, 6, 9, 6, 0, -9 },
  { 138, 6, 9, 6, 0, -9 },
  { 145, 3, 7, 3, 0, -7 },
  { 148, 4, 9, 3, -1, -7 },
  { 153, 6, 6, 6, 0, -7 },
  { 158, 5, 4, 6, 1, -6 },
  { 161, 5, 6, 6, 1, -7 },
  { 165, 5, 9, 5, 0, -9 },
  { 171, 9, 10, 8, 0, -9 },
  { 183, 7, 9, 6, -1, -9 },
  { 191, 6, 9, 6, 0, -9 },
  { 198, 6, 9, 6, 0, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 6, 9, 5, 0, -9 },
  { 220, 6, 9, 5, 0, -9 },
  { 227, 7, 9, 7, 0, -9 },
  { 235, 7, 9, 7, 0, -9 },
  { 243, 5, 9, 4, 0, -9 },
  { 249, 6, 12, 3, -2, -9 },
  { 258, 7, 9, 6, 0, -9 },
  { 266, 4, 9, 5, 0, -9 },
  { 271, 9, 9, 9, 0, -9 },
  { 282, 8, 9, 7, 0, -9 },
  { 291, 7, 9, 7, 0, -9 },
  { 299, 6, 9, 6, 0, -9 },
  { 306, 7, 11, 7, 0, -9 },
  { 316, 6, 9, 6, 0, -9 },
  { 323, 6, 9, 5, 0, -9 },
  { 330, 5, 9, 5, 1, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 6, 9, 6, 1, -9 },
  { 351, 9, 9, 9, 1, -9 },
  { 362, 8, 9, 6, -1, -9 },
  { 371, 6, 9, 6, 1, -9 },
  { 378, 6, 9, 5, 0, -9 },
  { 385, 5, 11, 3, -1, -9 },
  { 392, 3, 9, 5, 1, -9 },
  { 396, 5, 11, 3, -1, -9 },
  { 403, 6, 6, 6, 0, -9 },
  { 408, 5, 1, 5, -1, 1 },
  { 409, 2, 2, 4, 2, -9 },
  { 410, 6, 7, 6, 0, -7 },
  { 416, 6, 9, 6, 0, -9 },
  { 423, 5, 7, 5, 0, -7 },
  { 428, 7, 9, 6, 0, -9 },
  { 436, 5, 7, 6, 0, -7 },
  { 441, 6, 12, 4, -1, -9 },
  { 450, 6, 10, 6, 0, -7 },
  { 458, 6, 9, 6, 0, -9 },
  { 465, 4, 9, 3, 0, -9 },
  { 470, 6, 12, 3, -2, -9 },
  { 479, 6, 9, 6, 0, -9 },
  { 486, 4, 9, 3, 0, -9 },
  { 491, 9, 7, 9, 0, -7 },
  { 499, 6, 7, 6, 0, -7 },
  { 505, 6, 7, 6, 0, -7 },
  { 511, 7, 10, 6, -1, -7 },
  { 520, 6, 10, 6, 0, -7 },
  { 528, 5, 7, 4, 0, -7 },
  { 533, 5, 7, 5, 0, -7 },
  { 538, 5, 8, 4, 0, -8 },
  { 543, 6, 7, 6, 0, -7 },
  { 549, 5, 7, 5, 1, -7 },
  { 554, 8, 7, 8, 1, -7 },
  { 561, 7, 7, 6, -1, -7 },
  { 568, 7, 10, 5, -1, -7 },
  { 577, 6, 7, 5, -1, -7 },
  { 583, 5, 11, 4, 0, -9 },
  { 590, 2, 12, 5, 1, -9 },
  { 593, 5, 11, 4, -1, -9 },
  { 600, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC12PT7B_H_
