#ifndef _NOTOSANS_THIN14PT7B_H_
#define _NOTOSANS_THIN14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xFF, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21, 0x23, 0xFC,
  0x48, 0x24, 0x12, 0x00, 0x21, 0xEA, 0x28, 0xA1, 0x83, 0x89, 0x24, 0x9D,
  0x88, 0xE1, 0x49, 0x25, 0x12, 0x89, 0xBF, 0x64, 0x52, 0x29, 0x24, 0x91,
  0xC0, 0x78, 0x44, 0x44, 0x48, 0x30, 0x51, 0x89, 0x85, 0x82, 0x7D, 0xF0,
  0x6A, 0xAA, 0xA9, 0xC8, 0x92, 0x49, 0x25, 0x60, 0x20, 0x8A, 0xDC, 0x31,
  0x20, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xF0, 0xE0, 0x80, 0x11, 0x12, 0x22,
  0x44, 0x88, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x2E, 0x92,
  0x49, 0x24, 0xF8, 0x10, 0x41, 0x08, 0x41, 0x08, 0x43, 0xF0, 0xF8, 0x10,
  0x41, 0x78, 0x20, 0x41, 0x07, 0xE0, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44,
  0x84, 0x7F, 0x04, 0x04, 0xFA, 0x08, 0x20, 0xF8, 0x10, 0x41, 0x07, 0xE0,
  0x3D, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x85, 0xE0, 0xFC, 0x10, 0x82, 0x08,
  0x41, 0x08, 0x21, 0x00, 0x7A, 0x18, 0x72, 0x31, 0x28, 0x61, 0x85, 0xE0,
  0x7A, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x0B, 0xC0, 0x82, 0x87, 0x80, 0x0C,
  0xCC, 0x10, 0x30, 0x30, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0xC2, 0x33, 0x00,
  0xF1, 0x11, 0x24, 0x44, 0x04, 0x1F, 0x0C, 0x1A, 0x01, 0x47, 0x99, 0x13,
  0x42, 0x68, 0x8C, 0x92, 0x8D, 0x90, 0x01, 0xFC, 0x00, 0x10, 0x18, 0x14,
  0x24, 0x24, 0x42, 0x7E, 0x42, 0x81, 0x81, 0xFD, 0x06, 0x0C, 0x1F, 0xD0,
  0xA0, 0xC1, 0x83, 0xF8, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x7C, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x83, 0xF8,
  0x20, 0x82, 0x00, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x41,
  0x3F, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04, 0xEA, 0xAA,
  0xB0, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x87, 0x12, 0x45, 0x0E, 0x12, 0x22,
  0x44, 0x85, 0x04, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80,
  0xE0, 0x70, 0x74, 0x3A, 0x1C, 0x96, 0x4B, 0x29, 0x8C, 0xC4, 0x40, 0x83,
  0x86, 0x8D, 0x19, 0x31, 0x62, 0xC3, 0x83, 0x04, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x1F, 0x00, 0xFA, 0x18, 0x61, 0x87,
  0xE8, 0x20, 0x82, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x41, 0x1D, 0x01, 0x00, 0x40, 0xF9, 0x0A, 0x0C, 0x28, 0x5F, 0x22,
  0x44, 0x85, 0x04, 0x7E, 0x08, 0x20, 0x60, 0x60, 0x41, 0x07, 0xE0, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x81, 0x81, 0x42, 0x42, 0x44, 0x24,
  0x24, 0x18, 0x18, 0x10, 0x82, 0x14, 0x61, 0x46, 0x24, 0x52, 0x49, 0x22,
  0x92, 0x29, 0x42, 0x8C, 0x30, 0x81, 0x08, 0x82, 0x88, 0x91, 0x41, 0x02,
  0x0A, 0x22, 0x45, 0x04, 0x82, 0x85, 0x11, 0x42, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x7E, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFF, 0xF2,
  0x49, 0x24, 0x92, 0x70, 0x88, 0x44, 0x22, 0x21, 0x11, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x10, 0xC4, 0x92, 0x86, 0x10, 0xFC, 0xA4, 0x74, 0x42, 0x17,
  0xC6, 0x3F, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3A,
  0x21, 0x08, 0x42, 0x0F, 0x04, 0x10, 0x49, 0xCE, 0x18, 0x61, 0x86, 0x17,
  0xC0, 0x33, 0x28, 0x61, 0xFA, 0x08, 0x1F, 0x3A, 0x11, 0xE4, 0x21, 0x08,
  0x42, 0x10, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x1F, 0x80, 0x82,
  0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x40, 0x9F, 0xC0, 0x20, 0x12,
  0x49, 0x24, 0x9E, 0x84, 0x21, 0x08, 0xCA, 0x9C, 0x94, 0x62, 0xFF, 0xE0,
  0x33, 0xB3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x3B, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x3B, 0x18,
  0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x00, 0x72, 0x38, 0x61, 0x86, 0x18,
  0x5F, 0x04, 0x10, 0x40, 0x3C, 0x88, 0x88, 0x88, 0x7C, 0x21, 0x83, 0x04,
  0x3E, 0x4F, 0x44, 0x44, 0x44, 0x70, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0,
  0x86, 0x14, 0x92, 0x30, 0xC2, 0x00, 0x88, 0xC6, 0x55, 0x2A, 0x55, 0x31,
  0x08, 0x84, 0xC4, 0xA3, 0x04, 0x29, 0x28, 0x40, 0x86, 0x14, 0x92, 0x30,
  0xC2, 0x08, 0x23, 0x00, 0xF8, 0x88, 0x44, 0x43, 0xE0, 0x32, 0x22, 0x24,
  0xC2, 0x22, 0x23, 0xFF, 0xFE, 0xC2, 0x22, 0x22, 0x12, 0x22, 0x2E, 0x62,
  0x70,
};

const GFXglyph NotoSans_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 4, 4, 1, -10 },
  { 4, 9, 10, 9, 0, -10 },
  { 16, 6, 12, 8, 1, -11 },
  { 25, 9, 10, 11, 1, -10 },
  { 37, 8, 10, 10, 1, -10 },
  { 47, 1, 4, 2, 1, -10 },
  { 48, 2, 12, 4, 1, -10 },
  { 51, 3, 12, 4, 0, -10 },
  { 56, 6, 6, 8, 1, -11 },
  { 61, 6, 6, 8, 1, -8 },
  { 66, 1, 4, 3, 1, -2 },
  { 67, 3, 1, 5, 1, -4 },
  { 68, 1, 1, 3, 1, -1 },
  { 69, 4, 10, 5, 0, -10 },
  { 74, 6, 10, 8, 1, -10 },
  { 82, 3, 10, 8, 1, -10 },
  { 86, 6, 10, 8, 1, -10 },
  { 94, 6, 10, 8, 1, -10 },
  { 102, 8, 10, 8, 0, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 6, 10, 8, 1, -10 },
  { 136, 6, 10, 8, 1, -10 },
  { 144, 6, 10, 8, 1, -10 },
  { 152, 1, 7, 3, 1, -7 },
  { 153, 1, 9, 3, 1, -7 },
  { 155, 6, 6, 8, 1, -8 },
  { 160, 6, 4, 8, 1, -7 },
  { 163, 6, 6, 8, 1, -8 },
  { 168, 4, 10, 6, 1, -10 },
  { 173, 11, 11, 12, 1, -10 },
  { 189, 8, 10, 8, 0, -10 },
  { 199, 7, 10, 9, 1, -10 },
  { 208, 7, 10, 9, 1, -10 },
  { 217, 8, 10, 10, 1, -10 },
  { 227, 6, 10, 8, 1, -10 },
  { 235, 6, 10, 7, 1, -10 },
  { 243, 8, 10, 10, 1, -10 },
  { 253, 7, 10, 10, 1, -10 },
  { 262, 2, 10, 4, 1, -10 },
  { 265, 3, 12, 3, -1, -10 },
  { 270, 7, 10, 8, 1, -10 },
  { 279, 6, 10, 7, 1, -10 },
  { 287, 9, 10, 12, 1, -10 },
  { 299, 7, 10, 10, 1, -10 },
  { 308, 9, 10, 11, 1, -10 },
  { 320, 6, 10, 8, 1, -10 },
  { 328, 9, 12, 11, 1, -10 },
  { 342, 7, 10, 8, 1, -10 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 7, 10, 7, 0, -10 },
  { 368, 8, 10, 10, 1, -10 },
  { 378, 8, 10, 8, 0, -10 },
  { 388, 12, 10, 12, 0, -10 },
  { 403, 7, 10, 7, 0, -10 },
  { 412, 7, 10, 7, 0, -10 },
  { 421, 8, 10, 8, 0, -10 },
  { 431, 3, 12, 4, 1, -10 },
  { 436, 4, 10, 5, 0, -10 },
  { 441, 3, 12, 4, 0, -10 },
  { 446, 6, 6, 8, 1, -10 },
  { 451, 6, 1, 5, 0, 1 },
  { 452, 2, 3, 3, 1, -11 },
  { 453, 5, 8, 7, 1, -8 },
  { 458, 6, 11, 8, 1, -11 },
  { 467, 5, 8, 7, 1, -8 },
  { 472, 6, 11, 8, 1, -11 },
  { 481, 6, 8, 8, 1, -8 },
  { 487, 5, 11, 4, 0, -11 },
  { 494, 6, 11, 8, 1, -8 },
  { 503, 6, 11, 8, 1, -11 },
  { 512, 1, 10, 3, 1, -10 },
  { 514, 3, 13, 3, -1, -10 },
  { 519, 5, 11, 6, 1, -11 },
  { 526, 1, 11, 3, 1, -11 },
  { 528, 10, 8, 12, 1, -8 },
  { 538, 6, 8, 8, 1, -8 },
  { 544, 6, 8, 8, 1, -8 },
  { 550, 6, 11, 8, 1, -8 },
  { 559, 6, 11, 8, 1, -8 },
  { 568, 4, 8, 5, 1, -8 },
  { 572, 5, 8, 6, 1, -8 },
  { 577, 4, 9, 4, 0, -9 },
  { 582, 6, 7, 8, 1, -7 },
  { 588, 6, 7, 6, 0, -7 },
  { 594, 9, 7, 10, 0, -7 },
  { 602, 6, 7, 7, 0, -7 },
  { 608, 6, 10, 6, 0, -7 },
  { 616, 5, 7, 6, 1, -7 },
  { 621, 4, 12, 5, 0, -10 },
  { 627, 1, 15, 7, 3, -11 },
  { 629, 4, 12, 5, 0, -10 },
  { 635, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Thin14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin14pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_THIN14PT7B_H_
