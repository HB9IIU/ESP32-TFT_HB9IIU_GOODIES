#ifndef _NOTOSANS_THIN13PT7B_H_
#define _NOTOSANS_THIN13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x12, 0x12, 0x5F, 0x24, 0x24, 0xFF, 0x24, 0x24,
  0x48, 0x27, 0xE9, 0x4E, 0x18, 0xA5, 0x2F, 0x88, 0xE2, 0x4A, 0x25, 0x13,
  0x6A, 0xCA, 0xA4, 0x92, 0x49, 0x47, 0x00, 0x78, 0x88, 0x48, 0x30, 0x50,
  0x89, 0x86, 0x84, 0xFB, 0xE0, 0x6A, 0xAA, 0xA4, 0xC8, 0x92, 0x49, 0x2B,
  0x00, 0x21, 0x3E, 0x45, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x5A, 0xE0,
  0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x62,
  0x78, 0x74, 0x92, 0x49, 0x20, 0xF8, 0x42, 0x11, 0x10, 0x88, 0xF8, 0xF8,
  0x42, 0x17, 0x04, 0x21, 0xF8, 0x04, 0x18, 0x51, 0x24, 0x48, 0xAF, 0x82,
  0x04, 0xFA, 0x08, 0x3C, 0x08, 0x10, 0x41, 0xF8, 0x7A, 0x08, 0x3E, 0x86,
  0x18, 0x61, 0x78, 0xFC, 0x20, 0x84, 0x10, 0x42, 0x08, 0x40, 0xFA, 0x18,
  0x94, 0x7A, 0x18, 0x61, 0xF8, 0xFA, 0x28, 0x61, 0x89, 0xD0, 0x82, 0xF0,
  0x82, 0x40, 0x16, 0x80, 0x04, 0x66, 0x20, 0x60, 0x70, 0xFC, 0x0F, 0xC0,
  0x81, 0x81, 0x03, 0x33, 0x00, 0xF8, 0x42, 0x32, 0x10, 0x80, 0x20, 0x3F,
  0x10, 0x28, 0xC6, 0x49, 0xA2, 0x68, 0x9A, 0x26, 0x76, 0x80, 0x1F, 0x80,
  0x10, 0x18, 0x28, 0x24, 0x44, 0x7C, 0x42, 0x82, 0x81, 0xFE, 0x18, 0x61,
  0xFA, 0x18, 0x61, 0xF8, 0x7F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x7E,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xF8, 0xFC, 0x21, 0x0F, 0xC2,
  0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x7F, 0x02, 0x04, 0x08,
  0xF0, 0x60, 0xC1, 0x7E, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x82,
  0xEA, 0xAA, 0xC0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x86, 0x29, 0x28, 0xE2,
  0x48, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0xE0, 0xF0,
  0x74, 0x5A, 0x2C, 0xA6, 0x53, 0x31, 0x88, 0x80, 0x83, 0x86, 0x8D, 0x19,
  0x31, 0x62, 0xC3, 0x82, 0x7E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x7C, 0xFA, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x7E, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x74, 0x08, 0x06, 0xFA, 0x18, 0x61, 0xFA, 0x48,
  0xA1, 0x84, 0xFC, 0x21, 0x83, 0x04, 0x21, 0xF8, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7C,
  0x83, 0x05, 0x0A, 0x24, 0x45, 0x0A, 0x08, 0x10, 0x84, 0x28, 0x85, 0x29,
  0x25, 0x24, 0xA4, 0x52, 0x8C, 0x60, 0x84, 0x10, 0x80, 0x84, 0x88, 0xA1,
  0x81, 0x05, 0x12, 0x22, 0x82, 0x86, 0x89, 0x21, 0x43, 0x02, 0x04, 0x08,
  0x10, 0x7E, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0xFE, 0xF2, 0x49, 0x24,
  0x93, 0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x21, 0x44, 0xA2, 0x84, 0xF8, 0xB0, 0xF0, 0x42, 0xF8, 0xC7, 0xE0, 0x82,
  0x08, 0x3E, 0x86, 0x18, 0x61, 0x87, 0xE0, 0x7C, 0x21, 0x08, 0x41, 0xE0,
  0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x74, 0x63, 0xF8, 0x41, 0xE0,
  0x34, 0x4E, 0x44, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x0F, 0xC0,
  0x84, 0x21, 0xF8, 0xC6, 0x31, 0x8C, 0x40, 0xBF, 0x80, 0x20, 0x92, 0x49,
  0x24, 0xF0, 0x84, 0x21, 0x19, 0x53, 0x14, 0x94, 0x40, 0xFF, 0xC0, 0xF7,
  0xC4, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x22, 0xFC, 0x63, 0x18, 0xC6, 0x20,
  0x7A, 0x18, 0x61, 0x86, 0x17, 0x80, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0,
  0x82, 0x00, 0x7C, 0x63, 0x18, 0xC7, 0xE1, 0x08, 0x40, 0xF8, 0x88, 0x88,
  0x80, 0x7C, 0x10, 0x60, 0x87, 0xE0, 0x44, 0xF4, 0x44, 0x44, 0x70, 0x8C,
  0x63, 0x18, 0xC7, 0xE0, 0x86, 0x24, 0x92, 0x50, 0xC2, 0x00, 0x88, 0xC4,
  0x55, 0x4A, 0xA5, 0x53, 0x10, 0x88, 0x85, 0x23, 0x04, 0x31, 0x28, 0x40,
  0x86, 0x24, 0x92, 0x50, 0xC2, 0x08, 0x23, 0x00, 0xF1, 0x24, 0x48, 0xF0,
  0x34, 0x44, 0x48, 0x44, 0x44, 0x30, 0xFF, 0xF8, 0xE2, 0x22, 0x21, 0x22,
  0x22, 0xC0, 0xFC,
};

const GFXglyph NotoSans_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 8, 9, 8, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 9, 9, 10, 1, -9 },
  { 31, 8, 9, 9, 1, -9 },
  { 40, 1, 3, 2, 1, -9 },
  { 41, 2, 11, 3, 1, -9 },
  { 44, 3, 11, 3, 0, -9 },
  { 49, 5, 5, 7, 1, -10 },
  { 53, 6, 6, 7, 1, -8 },
  { 58, 2, 4, 2, 0, -2 },
  { 59, 3, 1, 4, 1, -4 },
  { 60, 1, 1, 3, 1, -1 },
  { 61, 4, 9, 4, 0, -9 },
  { 66, 6, 9, 7, 1, -9 },
  { 73, 3, 9, 7, 1, -9 },
  { 77, 5, 9, 7, 1, -9 },
  { 83, 5, 9, 7, 1, -9 },
  { 89, 7, 9, 7, 0, -9 },
  { 97, 6, 9, 7, 1, -9 },
  { 104, 6, 9, 7, 1, -9 },
  { 111, 6, 9, 7, 1, -9 },
  { 118, 6, 9, 7, 1, -9 },
  { 125, 6, 9, 7, 1, -9 },
  { 132, 1, 7, 3, 1, -7 },
  { 133, 2, 9, 3, 0, -7 },
  { 136, 6, 6, 7, 1, -8 },
  { 141, 6, 3, 7, 1, -6 },
  { 144, 6, 6, 7, 1, -8 },
  { 149, 5, 9, 5, 0, -9 },
  { 155, 10, 10, 11, 1, -9 },
  { 168, 8, 9, 8, 0, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 7, 9, 8, 1, -9 },
  { 192, 7, 9, 9, 1, -9 },
  { 200, 5, 9, 7, 1, -9 },
  { 206, 5, 9, 6, 1, -9 },
  { 212, 7, 9, 9, 1, -9 },
  { 220, 7, 9, 9, 1, -9 },
  { 228, 2, 9, 4, 1, -9 },
  { 231, 3, 11, 3, -1, -9 },
  { 236, 6, 9, 7, 1, -9 },
  { 243, 5, 9, 7, 1, -9 },
  { 249, 9, 9, 11, 1, -9 },
  { 260, 7, 9, 9, 1, -9 },
  { 268, 8, 9, 10, 1, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 8, 11, 10, 1, -9 },
  { 295, 6, 9, 8, 1, -9 },
  { 302, 5, 9, 7, 1, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 7, 9, 9, 1, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 11, 9, 11, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 7, 9, 7, 0, -9 },
  { 361, 7, 9, 8, 0, -9 },
  { 369, 3, 11, 4, 1, -9 },
  { 374, 4, 9, 4, 0, -9 },
  { 379, 3, 11, 4, 0, -9 },
  { 384, 6, 5, 7, 1, -9 },
  { 388, 5, 1, 5, 0, 1 },
  { 389, 2, 2, 3, 1, -10 },
  { 390, 5, 7, 7, 1, -7 },
  { 395, 6, 10, 8, 1, -10 },
  { 403, 5, 7, 6, 1, -7 },
  { 408, 5, 10, 8, 1, -10 },
  { 415, 5, 7, 7, 1, -7 },
  { 420, 4, 10, 4, 0, -10 },
  { 425, 5, 10, 8, 1, -7 },
  { 432, 5, 10, 7, 1, -10 },
  { 439, 1, 9, 3, 1, -9 },
  { 441, 3, 12, 3, -1, -9 },
  { 446, 5, 10, 6, 1, -10 },
  { 453, 1, 10, 3, 1, -10 },
  { 455, 9, 7, 11, 1, -7 },
  { 463, 5, 7, 7, 1, -7 },
  { 468, 6, 7, 7, 1, -7 },
  { 474, 6, 10, 8, 1, -7 },
  { 482, 5, 10, 8, 1, -7 },
  { 489, 4, 7, 5, 1, -7 },
  { 493, 5, 7, 6, 0, -7 },
  { 498, 4, 9, 4, 0, -9 },
  { 503, 5, 7, 7, 1, -7 },
  { 508, 6, 7, 6, 0, -7 },
  { 514, 9, 7, 9, 0, -7 },
  { 522, 6, 7, 6, 0, -7 },
  { 528, 6, 10, 6, 0, -7 },
  { 536, 4, 7, 6, 1, -7 },
  { 540, 4, 11, 4, 0, -9 },
  { 546, 1, 13, 7, 3, -10 },
  { 548, 4, 11, 4, 0, -9 },
  { 554, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_Thin13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin13pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_THIN13PT7B_H_
