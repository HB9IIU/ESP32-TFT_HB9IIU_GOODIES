#ifndef _NOTOSANS_THIN60PT7B_H_
#define _NOTOSANS_THIN60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x06,
  0x80, 0xD0, 0x1A, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0x99, 0xF8, 0x1C, 0x18, 0x1C, 0x30, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0x80, 0x18, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x98, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x19, 0xE0, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0xC0, 0x18, 0x38, 0xFC, 0x19,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x1C, 0x38, 0x00,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x01,
  0x80, 0x00, 0x80, 0x03, 0x01, 0x80, 0x00, 0x80, 0x03, 0x03, 0x00, 0x00,
  0x80, 0x03, 0x02, 0x00, 0x00, 0x80, 0x03, 0x06, 0x07, 0xE0, 0xC0, 0x03,
  0x04, 0x1C, 0x38, 0xC0, 0x02, 0x0C, 0x30, 0x1C, 0xC0, 0x06, 0x08, 0x20,
  0x0C, 0x60, 0x06, 0x18, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x40, 0x06, 0x30,
  0x18, 0x30, 0xC0, 0x02, 0x1C, 0x38, 0x60, 0xC0, 0x03, 0x0F, 0xE0, 0x60,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x00, 0x80, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x80, 0x03, 0x00, 0x01, 0x00, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x38, 0x01, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x61, 0x80, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x60, 0x00, 0x46, 0x00, 0x03,
  0x00, 0x0C, 0x40, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x00, 0xC0, 0x08, 0xC0,
  0x00, 0x06, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x10, 0x80, 0x00, 0x01, 0x83,
  0x08, 0x00, 0x00, 0x0C, 0x60, 0x80, 0x00, 0x00, 0x64, 0x0C, 0x00, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x60,
  0x00, 0x00, 0x66, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x38, 0x00, 0x03, 0x81,
  0x81, 0xC0, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x1F, 0xFF,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x55, 0x55, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x03, 0xFC, 0x04, 0x07, 0xC3,
  0xC2, 0x1E, 0x00, 0x3D, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x08, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x61, 0x86,
  0x18, 0x43, 0x0C, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x00, 0xFF, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x38, 0x07, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1A, 0x03, 0x90,
  0x30, 0x87, 0x04, 0x70, 0x26, 0x01, 0xE0, 0x0A, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x30, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C,
  0x0F, 0x80, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x72, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1F, 0x00,
  0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x04, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x01, 0xFF, 0x80,
  0x60, 0xF0, 0x1C, 0x0C, 0x70, 0x00, 0xE1, 0x98, 0x00, 0x06, 0x36, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x01, 0xC0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x06, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x06,
  0xC6, 0x00, 0x01, 0x98, 0x70, 0x00, 0xE3, 0x07, 0x80, 0x78, 0x60, 0x3F,
  0xFC, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x0C, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x86,
  0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x04, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x80,
  0x78, 0x40, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0x86, 0x00, 0x07, 0x80, 0xF0, 0x01, 0x8C, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x60, 0x01, 0x80, 0x01, 0x80, 0x04,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x09, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x16,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x78,
  0x00, 0x80, 0x00, 0x20, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x40, 0x01, 0xE0,
  0x02, 0x00, 0x00, 0x80, 0x02, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x05, 0x80,
  0x18, 0x00, 0x02, 0x00, 0x0B, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x36, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x40, 0x00, 0x30, 0x00, 0xD8, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0x10, 0x01, 0x80, 0x01, 0x60, 0x06, 0x20, 0x01,
  0x80, 0x06, 0xC0, 0x18, 0x60, 0x01, 0x80, 0x18, 0x80, 0x70, 0xC0, 0x03,
  0x80, 0xE1, 0xC1, 0xC0, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x78, 0x60, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x7C, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x01,
  0xF8, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x1E, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xD8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x3C,
  0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0xFF, 0x9F,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x3F, 0xE0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x30, 0x38, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x0C, 0x66, 0x00, 0x01, 0x98, 0x60, 0x00, 0x36, 0x0E,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00,
  0x00, 0x2F, 0x60, 0x00, 0x00, 0x01, 0xBC, 0x80, 0x00, 0x00, 0x06, 0xF3,
  0x00, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x00, 0xCF, 0x18, 0x00, 0x00,
  0x02, 0x3C, 0x60, 0x00, 0x00, 0x18, 0xF0, 0x80, 0x00, 0x00, 0x63, 0xC3,
  0x00, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x00, 0x0C, 0x3C, 0x18, 0x00, 0x00,
  0x20, 0xF0, 0x60, 0x00, 0x01, 0x83, 0xC0, 0x80, 0x00, 0x06, 0x0F, 0x03,
  0x00, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x00, 0xC0, 0xF0, 0x18, 0x00, 0x02,
  0x03, 0xC0, 0x60, 0x00, 0x18, 0x0F, 0x00, 0x80, 0x00, 0x60, 0x3C, 0x03,
  0x00, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x20,
  0x0F, 0x00, 0x60, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x04, 0x00, 0xF0, 0x03,
  0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x02, 0x00,
  0x3C, 0x00, 0x60, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x40, 0x03, 0xC0, 0x03,
  0x03, 0x00, 0x0F, 0x00, 0x04, 0x0C, 0x00, 0x3C, 0x00, 0x18, 0x60, 0x00,
  0xF0, 0x00, 0x61, 0x80, 0x03, 0xC0, 0x00, 0xC4, 0x00, 0x0F, 0x00, 0x03,
  0x30, 0x00, 0x3C, 0x00, 0x04, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x60, 0x00,
  0x00, 0x3C, 0xC0, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00, 0xF0,
  0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x00, 0xC0,
  0x0F, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x0C, 0x03,
  0xC0, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0xC0, 0xF0,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x0C, 0x3C, 0x00,
  0x00, 0x18, 0xF0, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00,
  0x01, 0xBC, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x1E, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC3, 0x00,
  0x03, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xE0,
  0xE0, 0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x3F, 0x00, 0x1E, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x08, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x30, 0x04, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x02, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x01, 0x01, 0x80, 0x00, 0x81, 0x80, 0x01, 0x81, 0x00, 0x00, 0xC1,
  0x80, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x83, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x62, 0x00, 0x00, 0x46, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xFF, 0x80, 0x1F,
  0x83, 0xC0, 0x70, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xC0, 0x06, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xB6, 0x00, 0x02, 0x66, 0x00, 0x18, 0xC7, 0x00,
  0xE1, 0x87, 0xFF, 0x03, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x07, 0xFE, 0x03, 0x07, 0x81, 0xE0, 0xC7,
  0x00, 0x1C, 0x33, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x33, 0x60, 0x00, 0x0C,
  0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0B, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x2E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xF0, 0x00, 0x03, 0x36, 0x00, 0x01, 0x8C,
  0x80, 0x00, 0xE3, 0x38, 0x00, 0x70, 0xC3, 0x80, 0x70, 0x30, 0x7F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x7C, 0x0E, 0x00,
  0x08, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x0F, 0xFC, 0x0C, 0x0F, 0x83, 0xC3, 0x07, 0x00, 0x18, 0xC3, 0x00,
  0x03, 0x31, 0x80, 0x00, 0x6C, 0xC0, 0x00, 0x0B, 0x20, 0x00, 0x03, 0xD8,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x74, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x0F, 0x20, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xB1, 0x80, 0x00, 0xCC, 0x30,
  0x00, 0x63, 0x07, 0x80, 0x70, 0xC0, 0x7F, 0xF8, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xF0, 0xF8, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x03,
  0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x7C, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xC0, 0xF8, 0x3C, 0x30, 0x60, 0x01, 0x8C, 0x30, 0x00, 0x33, 0x18,
  0x00, 0x06, 0xCC, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x40, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x40, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xF2, 0x00,
  0x00, 0x2C, 0xC0, 0x00, 0x1B, 0x18, 0x00, 0x0C, 0xC3, 0x00, 0x06, 0x30,
  0x78, 0x07, 0x0C, 0x07, 0xFF, 0x03, 0x00, 0x1A, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x70, 0x3F, 0x00, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF,
  0xC0, 0xC3, 0xE0, 0xF0, 0xC7, 0x00, 0x1C, 0xCC, 0x00, 0x0C, 0xD8, 0x00,
  0x06, 0xD0, 0x00, 0x02, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x64, 0x18, 0xFE, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x78, 0x00,
  0x31, 0x98, 0x00, 0x66, 0x18, 0x00, 0xD8, 0x10, 0x01, 0xE0, 0x30, 0x03,
  0x80, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x98, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x61, 0xE1, 0xE0, 0x3C, 0x1E, 0x33, 0x80, 0x18,
  0x30, 0x03, 0x99, 0x00, 0x06, 0x30, 0x00, 0xED, 0x00, 0x01, 0x30, 0x00,
  0x37, 0x80, 0x00, 0xF0, 0x00, 0x0B, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x7F, 0xC0, 0xC3, 0xE0,
  0xF0, 0xC7, 0x00, 0x18, 0xCC, 0x00, 0x0C, 0xD8, 0x00, 0x06, 0xD0, 0x00,
  0x02, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x7F, 0xE0, 0x18, 0x3E, 0x0F, 0x03, 0x0C, 0x00, 0x70, 0x63, 0x00, 0x03,
  0x0C, 0xC0, 0x00, 0x31, 0xB0, 0x00, 0x02, 0x34, 0x00, 0x00, 0x67, 0x80,
  0x00, 0x04, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x04, 0xE0, 0x00, 0x01, 0x9E,
  0x00, 0x00, 0x33, 0x40, 0x00, 0x0C, 0x6C, 0x00, 0x01, 0x8C, 0xC0, 0x00,
  0x61, 0x8C, 0x00, 0x38, 0x30, 0xE0, 0x1E, 0x06, 0x07, 0xFF, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x40, 0x78, 0x1E, 0x10, 0x30, 0x00, 0xC4, 0x38, 0x00, 0x19,
  0x0C, 0x00, 0x03, 0x46, 0x00, 0x00, 0x53, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x34, 0x60, 0x00, 0x0D, 0x0C, 0x00, 0x06, 0x43, 0x80, 0x03,
  0x10, 0x38, 0x03, 0x84, 0x07, 0xFF, 0x81, 0x00, 0x1E, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0xC0, 0xFF, 0xE1, 0xE1, 0xB1, 0x80, 0x19,
  0x80, 0x0D, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0x83, 0xF8, 0x70, 0x00, 0x20, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x07, 0x3E, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x81, 0x01, 0xFF, 0x00, 0x18, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x40, 0x00, 0x0F, 0x60, 0x00, 0x0B, 0x30, 0x00,
  0x13, 0x18, 0x00, 0x61, 0x0E, 0x01, 0xC1, 0x07, 0xFF, 0x81, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x60, 0x00, 0x1B,
  0x00, 0x01, 0xE0, 0x00, 0x26, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x04,
  0x80, 0x01, 0x88, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x04,
  0x30, 0x00, 0x42, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03,
  0x0C, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x81, 0x80, 0x18, 0x18, 0x03,
  0x01, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0x80,
  0xC0, 0x18, 0x18, 0x01, 0x81, 0x00, 0x10, 0x30, 0x03, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x0C,
  0x20, 0x00, 0x84, 0x00, 0x08, 0xC0, 0x01, 0x98, 0x00, 0x11, 0x80, 0x03,
  0x30, 0x00, 0x32, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00,
  0x58, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x43, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x87, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0x70, 0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x0E, 0x80,
  0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 43, 13, 5, -43 },
  { 18, 11, 16, 19, 4, -43 },
  { 40, 35, 43, 39, 2, -43 },
  { 229, 24, 49, 34, 4, -46 },
  { 376, 40, 44, 48, 4, -43 },
  { 596, 36, 45, 42, 4, -44 },
  { 799, 2, 16, 10, 4, -43 },
  { 803, 10, 52, 15, 3, -43 },
  { 868, 11, 52, 15, 2, -43 },
  { 940, 25, 24, 33, 4, -45 },
  { 1015, 28, 28, 34, 3, -35 },
  { 1113, 6, 15, 11, 2, -7 },
  { 1125, 15, 1, 19, 2, -17 },
  { 1127, 3, 3, 13, 5, -3 },
  { 1129, 18, 43, 19, 1, -43 },
  { 1226, 26, 45, 34, 4, -44 },
  { 1373, 13, 43, 34, 6, -43 },
  { 1443, 25, 43, 34, 4, -43 },
  { 1578, 27, 44, 34, 3, -43 },
  { 1727, 33, 43, 34, 1, -43 },
  { 1905, 26, 44, 34, 4, -43 },
  { 2048, 27, 45, 34, 4, -44 },
  { 2200, 28, 43, 34, 3, -43 },
  { 2351, 26, 44, 34, 4, -43 },
  { 2494, 27, 44, 34, 3, -43 },
  { 2643, 3, 32, 13, 5, -32 },
  { 2655, 6, 40, 13, 2, -32 },
  { 2685, 28, 27, 34, 3, -35 },
  { 2780, 28, 14, 34, 3, -28 },
  { 2829, 28, 27, 34, 3, -35 },
  { 2924, 20, 43, 25, 2, -43 },
  { 3032, 47, 48, 53, 3, -42 },
  { 3314, 35, 43, 35, 0, -43 },
  { 3503, 27, 43, 37, 6, -43 },
  { 3649, 31, 44, 37, 4, -43 },
  { 3820, 32, 43, 42, 6, -43 },
  { 3992, 23, 43, 33, 6, -43 },
  { 4116, 23, 43, 30, 6, -43 },
  { 4240, 34, 45, 43, 4, -44 },
  { 4432, 30, 43, 42, 6, -43 },
  { 4594, 9, 43, 17, 4, -43 },
  { 4643, 14, 53, 14, -6, -43 },
  { 4736, 27, 43, 33, 6, -43 },
  { 4882, 23, 43, 30, 6, -43 },
  { 5006, 38, 43, 50, 6, -43 },
  { 5211, 30, 43, 42, 6, -43 },
  { 5373, 37, 45, 45, 4, -44 },
  { 5582, 25, 43, 34, 6, -43 },
  { 5717, 37, 54, 45, 4, -44 },
  { 5967, 27, 43, 35, 6, -43 },
  { 6113, 26, 44, 33, 3, -43 },
  { 6256, 30, 43, 30, 0, -43 },
  { 6418, 31, 44, 43, 6, -43 },
  { 6589, 34, 43, 34, 0, -43 },
  { 6772, 48, 43, 52, 2, -43 },
  { 7030, 31, 43, 31, 0, -43 },
  { 7197, 30, 43, 30, 0, -43 },
  { 7359, 30, 43, 35, 2, -43 },
  { 7521, 12, 52, 19, 5, -43 },
  { 7599, 18, 43, 19, 1, -43 },
  { 7696, 13, 52, 19, 1, -43 },
  { 7781, 28, 26, 34, 3, -43 },
  { 7872, 24, 2, 23, 0, 5 },
  { 7878, 11, 10, 15, 2, -46 },
  { 7892, 23, 33, 31, 3, -32 },
  { 7987, 26, 47, 35, 5, -46 },
  { 8140, 23, 33, 28, 4, -32 },
  { 8235, 26, 47, 35, 4, -46 },
  { 8388, 25, 33, 32, 4, -32 },
  { 8492, 19, 46, 16, 1, -46 },
  { 8602, 26, 46, 35, 4, -32 },
  { 8752, 24, 46, 34, 5, -46 },
  { 8890, 3, 43, 12, 5, -43 },
  { 8907, 11, 57, 12, -3, -43 },
  { 8986, 23, 46, 27, 5, -46 },
  { 9119, 2, 46, 12, 5, -46 },
  { 9131, 41, 32, 51, 5, -32 },
  { 9295, 24, 32, 34, 5, -32 },
  { 9391, 27, 33, 35, 4, -32 },
  { 9503, 27, 46, 35, 5, -32 },
  { 9659, 26, 46, 35, 3, -32 },
  { 9809, 17, 32, 23, 5, -32 },
  { 9877, 23, 33, 27, 2, -32 },
  { 9972, 16, 41, 19, 1, -40 },
  { 10054, 24, 33, 34, 5, -32 },
  { 10153, 26, 32, 26, 0, -32 },
  { 10257, 39, 32, 41, 1, -32 },
  { 10413, 25, 32, 29, 2, -32 },
  { 10513, 26, 47, 26, 0, -32 },
  { 10666, 23, 32, 27, 2, -32 },
  { 10758, 16, 52, 20, 2, -43 },
  { 10862, 2, 61, 32, 15, -46 },
  { 10878, 17, 52, 20, 2, -43 },
  { 10989, 28, 5, 34, 3, -24 },
};

const GFXfont NotoSans_Thin60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin60pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_THIN60PT7B_H_
