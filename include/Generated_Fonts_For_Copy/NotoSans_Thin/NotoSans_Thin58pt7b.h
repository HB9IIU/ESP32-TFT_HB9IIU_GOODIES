#ifndef _NOTOSANS_THIN58PT7B_H_
#define _NOTOSANS_THIN58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0x3F, 0xE0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x04,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x04, 0x00, 0x20, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x03, 0x82, 0x07,
  0x0C, 0x04, 0x02, 0x30, 0x08, 0x00, 0x40, 0x10, 0x01, 0x80, 0x20, 0x03,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x40, 0x00, 0xC0, 0x80, 0x00, 0xE1, 0x00, 0x00, 0x72, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x17, 0x80, 0x00, 0x23, 0xC0, 0x00, 0x41,
  0xC0, 0x00, 0x80, 0xC0, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x04, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x30, 0x01, 0x00, 0x60, 0x02, 0x00, 0x80, 0x04, 0x03, 0x00,
  0x08, 0x0C, 0x80, 0x10, 0x31, 0xF8, 0x23, 0xC0, 0x7F, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x02, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x30, 0x06, 0x00, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x01,
  0x80, 0x00, 0x40, 0x01, 0x03, 0x00, 0x00, 0x40, 0x01, 0x03, 0x00, 0x00,
  0x40, 0x03, 0x06, 0x0F, 0xE0, 0x60, 0x03, 0x04, 0x18, 0x38, 0x60, 0x03,
  0x0C, 0x30, 0x18, 0x60, 0x02, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x60,
  0x04, 0x30, 0x04, 0x10, 0x40, 0x06, 0x18, 0x0C, 0x30, 0xC0, 0x06, 0x0F,
  0x78, 0x60, 0xC0, 0x02, 0x03, 0xE0, 0x60, 0x80, 0x02, 0x00, 0x00, 0xC0,
  0x80, 0x02, 0x00, 0x00, 0x80, 0x80, 0x03, 0x00, 0x01, 0x80, 0x80, 0x03,
  0x00, 0x01, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x20, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x40, 0x00, 0x18, 0x38,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x30, 0x00, 0xC0, 0x00, 0x8C,
  0x00, 0x0C, 0x00, 0x31, 0x00, 0x00, 0xC0, 0x06, 0x60, 0x00, 0x0C, 0x00,
  0x8C, 0x00, 0x00, 0xC0, 0x31, 0x00, 0x00, 0x0C, 0x04, 0x20, 0x00, 0x00,
  0xC1, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x80, 0x00, 0x00, 0xCC, 0x10, 0x00,
  0x00, 0x1F, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x04,
  0x00, 0x00, 0x0D, 0x80, 0xC0, 0x00, 0x03, 0x18, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0xE0, 0x00, 0x70, 0x18, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x7F, 0xFC,
  0x00, 0x1C, 0x00, 0xE8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x1C, 0xE0, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xC0,
  0x10, 0x03, 0xF0, 0x10, 0x1F, 0x1E, 0x10, 0xF8, 0x03, 0xD3, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x24, 0x00, 0x00, 0x46, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x81, 0x00, 0x01, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x18, 0xC4,
  0x60, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xF1, 0xF0, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x76, 0x06, 0x30, 0xE1, 0x8E, 0x0C, 0xC0, 0x7C,
  0x03, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x01, 0xFB,
  0xF0, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0xF8, 0x01, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x70, 0xFC, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFE, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x63, 0x80, 0x00, 0xE0,
  0xF8, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xC7, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x3F, 0xF8, 0x0C, 0x3C, 0x03, 0x83,
  0x18, 0x00, 0x30, 0xDC, 0x00, 0x06, 0x24, 0x00, 0x00, 0xCB, 0x00, 0x00,
  0x13, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x80, 0x78, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x18, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x24, 0x00, 0x00, 0x33, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x01, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x05, 0x30, 0x00, 0x03,
  0xCC, 0x00, 0x01, 0xB1, 0x80, 0x00, 0xCC, 0x38, 0x00, 0xE3, 0x03, 0xE7,
  0xE0, 0xC0, 0x3F, 0xE0, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x20, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xDF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x18, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C,
  0x20, 0x86, 0x18, 0x43, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07,
  0xFB, 0xE0, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0x18, 0x00, 0x1C, 0x07, 0x80,
  0x18, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x4C, 0x00, 0x30, 0x00, 0x60, 0x02,
  0x60, 0x03, 0x00, 0x03, 0x00, 0x1A, 0x00, 0x10, 0x00, 0x10, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0x80, 0x07, 0x80, 0x08, 0x00, 0x04, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x20, 0x01, 0xE0, 0x06, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x78, 0x01, 0x80, 0x00, 0x40, 0x03, 0xC0, 0x0C, 0x00,
  0x02, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x30, 0x00, 0xB0, 0x03, 0x00, 0x01,
  0x80, 0x05, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x6C, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0x60, 0x02, 0x00, 0x05, 0x00, 0x11, 0x00, 0x18, 0x00, 0x6C, 0x01,
  0x88, 0x00, 0x60, 0x06, 0x60, 0x18, 0x60, 0x01, 0x80, 0x61, 0x81, 0x83,
  0x00, 0x07, 0xFE, 0x07, 0xF8, 0x08, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x3E, 0x08, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0E, 0x20, 0x00, 0x0E, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x78, 0x20, 0x00, 0x03,
  0x88, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x88, 0x00, 0x01, 0xC2, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x01, 0xE0, 0x20, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x38, 0x08, 0x00, 0x07, 0x80, 0x20,
  0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x08, 0x38, 0x00, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x02, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0xFF, 0x8C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xCF, 0x07, 0xF0,
  0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x06,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0xE0, 0x00, 0x08,
  0x6C, 0x00, 0x02, 0x31, 0x80, 0x00, 0x98, 0x60, 0x00, 0x2C, 0x0C, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x08, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x20,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x00, 0x1F, 0x60, 0x00,
  0x00, 0x00, 0xB9, 0x00, 0x00, 0x00, 0x0D, 0xCC, 0x00, 0x00, 0x00, 0x4E,
  0x20, 0x00, 0x00, 0x06, 0x71, 0x80, 0x00, 0x00, 0x33, 0x8C, 0x00, 0x00,
  0x01, 0x1C, 0x20, 0x00, 0x00, 0x18, 0xE1, 0x80, 0x00, 0x00, 0x87, 0x04,
  0x00, 0x00, 0x0C, 0x38, 0x30, 0x00, 0x00, 0x61, 0xC1, 0x80, 0x00, 0x06,
  0x0E, 0x06, 0x00, 0x00, 0x30, 0x70, 0x30, 0x00, 0x01, 0x03, 0x80, 0x80,
  0x00, 0x18, 0x1C, 0x06, 0x00, 0x00, 0x80, 0xE0, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0xC0, 0x00, 0x60, 0x38, 0x06, 0x00, 0x02, 0x01, 0xC0, 0x10, 0x00,
  0x30, 0x0E, 0x00, 0xC0, 0x01, 0x00, 0x70, 0x06, 0x00, 0x18, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x60,
  0x07, 0x00, 0x18, 0x02, 0x00, 0x38, 0x00, 0x40, 0x30, 0x01, 0xC0, 0x03,
  0x01, 0x80, 0x0E, 0x00, 0x18, 0x08, 0x00, 0x70, 0x00, 0x40, 0xC0, 0x03,
  0x80, 0x03, 0x04, 0x00, 0x1C, 0x00, 0x08, 0x60, 0x00, 0xE0, 0x00, 0x63,
  0x00, 0x07, 0x00, 0x03, 0x30, 0x00, 0x38, 0x00, 0x09, 0x80, 0x01, 0xC0,
  0x00, 0x68, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80,
  0x03, 0xE0, 0x80, 0x00, 0x38, 0x80, 0x00, 0x1C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x7C, 0x08,
  0x00, 0x03, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x82, 0x00, 0x01, 0xC0, 0x80, 0x01,
  0xC0, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x80,
  0x03, 0x00, 0x20, 0x00, 0x60, 0x08, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x40, 0x20, 0x00, 0x18, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x18, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFD,
  0xFF, 0x01, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x19, 0x00, 0x00, 0x38,
  0xF8, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x2D, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x90, 0x00, 0x03, 0x08, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x20, 0x00, 0x08, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0x00, 0x01, 0x01, 0x80, 0x01, 0x02, 0x00, 0x06, 0x01,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x04, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x08,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x20, 0x02, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x00, 0x40,
  0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x40, 0x01, 0x80,
  0x40, 0x03, 0x01, 0x80, 0x01, 0x00, 0x80, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x30, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x20, 0x80, 0x00, 0x30, 0x80, 0x00, 0x43, 0x00, 0x00, 0x21, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x01, 0x20, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0xFF,
  0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x1F, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x04, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x03, 0x00, 0x30, 0x00, 0x20, 0x04, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0x0F, 0x01, 0xC0, 0x07, 0x04, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0x0E, 0x00, 0x0C, 0xE0,
  0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x02, 0xD8, 0x00, 0x1B, 0x70, 0x00, 0xCC, 0xE0, 0x1E, 0x30, 0xFF,
  0xE0, 0x40, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x07, 0xFE, 0x03,
  0x0F, 0x83, 0xC1, 0x8C, 0x00, 0x30, 0xCC, 0x00, 0x0C, 0x6C, 0x00, 0x03,
  0x3C, 0x00, 0x00, 0x9E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x17, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1B, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x0C, 0xD8, 0x00, 0x0C,
  0x66, 0x00, 0x1C, 0x31, 0xC0, 0x3C, 0x10, 0x3F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x08, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x30, 0x1E, 0x0F, 0x0C, 0x1C, 0x00,
  0x63, 0x0E, 0x00, 0x0C, 0xC2, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x3C, 0xC0,
  0x00, 0x0F, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC8, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x0B, 0x1C, 0x00, 0x04, 0xC3, 0x80,
  0x03, 0x30, 0x38, 0x03, 0x0C, 0x07, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x10, 0x1E, 0x00, 0x78, 0x03, 0xFF,
  0xF0, 0x00, 0x0D, 0x00, 0x00, 0x3F, 0xE0, 0x1C, 0x08, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x7C, 0x3C, 0x30, 0x70, 0x01, 0xCC, 0x30,
  0x00, 0x13, 0x08, 0x00, 0x02, 0xC6, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0xF1, 0x80, 0x00, 0x6C, 0x30, 0x00, 0x13, 0x06, 0x00, 0x1C, 0xC0,
  0xE0, 0x1C, 0x30, 0x1F, 0xFE, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x03, 0x83, 0xC0, 0x01, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x1F, 0xF0, 0x30, 0xF8, 0x78, 0x63,
  0x00, 0x1C, 0xCC, 0x00, 0x19, 0xB0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x10, 0xDB,
  0xE0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xD8, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x3F, 0xC3, 0xE0, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0,
  0x00, 0xC6, 0xC0, 0x03, 0x31, 0x80, 0x0D, 0x83, 0x00, 0x3C, 0x0C, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0x87, 0x83, 0x80, 0xF0, 0x70, 0xCC, 0x00, 0xC1, 0x80, 0x18, 0xD8,
  0x00, 0x63, 0x00, 0x0C, 0xD0, 0x00, 0x36, 0x00, 0x06, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0xFF, 0x81, 0x07, 0x83,
  0xC3, 0x18, 0x00, 0xE6, 0x60, 0x00, 0xCD, 0x80, 0x00, 0xDE, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x0C, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x07, 0x80, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x7F, 0xC0, 0x30, 0x78, 0x3C, 0x0C, 0x70, 0x01, 0x83, 0x30,
  0x00, 0x30, 0xD8, 0x00, 0x06, 0x34, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x04, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x04, 0xE0, 0x00, 0x03, 0x3C, 0x00,
  0x00, 0x8D, 0x80, 0x00, 0x63, 0x70, 0x00, 0x30, 0xCE, 0x00, 0x18, 0x31,
  0xE0, 0x1C, 0x0C, 0x1F, 0xFC, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x80, 0xF0, 0x78, 0x41, 0xC0, 0x06, 0x21, 0x80, 0x01,
  0x91, 0x80, 0x00, 0x68, 0x80, 0x00, 0x14, 0xC0, 0x00, 0x0E, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x20, 0x00, 0x03, 0x98, 0x00, 0x01, 0x44, 0x00, 0x01,
  0xA3, 0x00, 0x01, 0x90, 0xC0, 0x01, 0x88, 0x38, 0x03, 0x84, 0x07, 0xFF,
  0x02, 0x00, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0xC1, 0xFF, 0xC7, 0xC7, 0xCC, 0x00,
  0xD8, 0x00, 0xD0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x1E,
  0x0F, 0xE1, 0xC0, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x33, 0xE0, 0x07, 0x81, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x01, 0x01, 0xFF, 0x00, 0x10, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x4B,
  0x00, 0x01, 0x93, 0x00, 0x06, 0x23, 0x80, 0x78, 0x41, 0xFF, 0xC0, 0x80,
  0x70, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x03, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x34, 0x00, 0x03, 0x80, 0x00, 0x90, 0x00, 0x0E, 0x00, 0x06, 0x60, 0x00,
  0x68, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x42, 0x00, 0x04, 0xC0, 0x01,
  0x0C, 0x00, 0x31, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x40, 0x02,
  0x18, 0x00, 0x81, 0x00, 0x18, 0x20, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x01, 0x03, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0x80, 0xC0,
  0x10, 0x18, 0x02, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x10, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00,
  0x31, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00,
  0x32, 0x00, 0x06, 0xC0, 0x00, 0x48, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00,
  0x28, 0x00, 0x07, 0x80, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x01,
  0x80, 0x01, 0x83, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x64,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x80, 0x03, 0x01,
  0x80, 0x02, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0x00, 0x60, 0x00, 0x80, 0x20,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x0E, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x05, 0x80, 0x38, 0x03, 0xC0,
  0x01, 0xE1, 0xC8, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 41, 13, 5, -41 },
  { 17, 10, 15, 19, 4, -41 },
  { 36, 34, 41, 37, 2, -41 },
  { 211, 23, 47, 33, 4, -44 },
  { 347, 40, 43, 46, 3, -42 },
  { 562, 35, 43, 41, 4, -42 },
  { 751, 2, 15, 10, 4, -41 },
  { 755, 11, 50, 15, 2, -41 },
  { 824, 10, 50, 15, 2, -41 },
  { 887, 24, 23, 32, 4, -44 },
  { 956, 27, 27, 33, 3, -34 },
  { 1048, 5, 14, 11, 2, -7 },
  { 1057, 14, 1, 19, 2, -16 },
  { 1059, 3, 3, 13, 5, -3 },
  { 1061, 17, 41, 19, 1, -41 },
  { 1149, 25, 43, 33, 4, -42 },
  { 1284, 13, 41, 33, 6, -41 },
  { 1351, 25, 42, 33, 3, -42 },
  { 1483, 26, 43, 33, 3, -42 },
  { 1623, 31, 42, 33, 1, -42 },
  { 1786, 25, 42, 33, 4, -41 },
  { 1918, 26, 43, 33, 4, -42 },
  { 2058, 27, 41, 33, 3, -41 },
  { 2197, 25, 43, 33, 4, -42 },
  { 2332, 26, 43, 33, 3, -42 },
  { 2472, 3, 31, 13, 5, -31 },
  { 2484, 6, 38, 13, 2, -31 },
  { 2513, 27, 26, 33, 3, -34 },
  { 2601, 27, 13, 33, 3, -27 },
  { 2645, 27, 26, 33, 3, -34 },
  { 2733, 20, 42, 24, 2, -42 },
  { 2838, 45, 47, 51, 3, -41 },
  { 3103, 33, 42, 33, 0, -42 },
  { 3277, 26, 41, 36, 6, -41 },
  { 3411, 30, 43, 36, 4, -42 },
  { 3573, 30, 41, 40, 6, -41 },
  { 3727, 22, 41, 32, 6, -41 },
  { 3840, 22, 41, 29, 6, -41 },
  { 3953, 33, 43, 42, 4, -42 },
  { 4131, 29, 41, 41, 6, -41 },
  { 4280, 9, 41, 16, 4, -41 },
  { 4327, 14, 51, 13, -6, -41 },
  { 4417, 26, 41, 32, 6, -41 },
  { 4551, 22, 41, 29, 6, -41 },
  { 4664, 37, 41, 49, 6, -41 },
  { 4854, 28, 41, 40, 6, -41 },
  { 4998, 36, 43, 44, 4, -42 },
  { 5192, 24, 41, 33, 6, -41 },
  { 5315, 36, 52, 44, 4, -42 },
  { 5549, 26, 41, 33, 6, -41 },
  { 5683, 25, 43, 32, 3, -42 },
  { 5818, 29, 41, 29, 0, -41 },
  { 5967, 30, 42, 41, 6, -41 },
  { 6125, 33, 41, 33, 0, -41 },
  { 6295, 47, 41, 50, 2, -41 },
  { 6536, 30, 41, 30, 0, -41 },
  { 6690, 29, 41, 29, 0, -41 },
  { 6839, 29, 41, 34, 2, -41 },
  { 6988, 12, 50, 18, 5, -41 },
  { 7063, 17, 41, 19, 1, -41 },
  { 7151, 12, 50, 18, 1, -41 },
  { 7226, 27, 26, 33, 3, -42 },
  { 7314, 23, 2, 23, 0, 5 },
  { 7320, 10, 9, 14, 2, -44 },
  { 7332, 22, 32, 30, 3, -31 },
  { 7420, 25, 45, 34, 5, -44 },
  { 7561, 23, 32, 27, 3, -31 },
  { 7653, 26, 45, 34, 3, -44 },
  { 7800, 25, 32, 31, 3, -31 },
  { 7900, 19, 44, 16, 1, -44 },
  { 8005, 26, 45, 34, 3, -31 },
  { 8152, 23, 44, 33, 5, -44 },
  { 8279, 3, 42, 12, 5, -42 },
  { 8295, 11, 56, 12, -3, -42 },
  { 8372, 22, 44, 26, 5, -44 },
  { 8493, 2, 44, 12, 5, -44 },
  { 8504, 40, 31, 49, 5, -31 },
  { 8659, 23, 31, 33, 5, -31 },
  { 8749, 27, 32, 33, 3, -31 },
  { 8857, 26, 44, 34, 5, -31 },
  { 9000, 25, 44, 34, 3, -31 },
  { 9138, 16, 31, 22, 5, -31 },
  { 9200, 22, 32, 27, 2, -31 },
  { 9288, 16, 39, 19, 1, -38 },
  { 9366, 23, 32, 33, 5, -31 },
  { 9458, 25, 31, 25, 0, -31 },
  { 9555, 38, 31, 40, 1, -31 },
  { 9703, 24, 31, 28, 2, -31 },
  { 9796, 25, 45, 25, 0, -31 },
  { 9937, 22, 31, 26, 2, -31 },
  { 10023, 15, 50, 20, 2, -41 },
  { 10117, 1, 59, 31, 15, -44 },
  { 10125, 16, 50, 20, 2, -41 },
  { 10225, 27, 5, 33, 3, -23 },
};

const GFXfont NotoSans_Thin58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin58pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_THIN58PT7B_H_
