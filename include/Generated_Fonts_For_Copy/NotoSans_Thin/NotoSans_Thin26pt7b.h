#ifndef _NOTOSANS_THIN26PT7B_H_
#define _NOTOSANS_THIN26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x0C, 0x99, 0x99, 0x99, 0x90, 0x02, 0x08,
  0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F, 0xFF, 0x84,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC2, 0x08,
  0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x41, 0x00, 0x82, 0x00, 0x08, 0x02,
  0x03, 0xFB, 0x20, 0x88, 0x22, 0x08, 0x82, 0x20, 0xC8, 0x0A, 0x01, 0xC0,
  0x2C, 0x08, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42, 0x18, 0x99, 0xF0, 0x08,
  0x02, 0x00, 0x38, 0x04, 0x22, 0x04, 0x21, 0x02, 0x10, 0x42, 0x08, 0x21,
  0x04, 0x11, 0x02, 0x08, 0x81, 0x04, 0x88, 0x82, 0x9B, 0x42, 0x48, 0x51,
  0x48, 0x27, 0x24, 0x10, 0x22, 0x08, 0x11, 0x04, 0x10, 0x82, 0x08, 0x41,
  0x08, 0x20, 0x84, 0x08, 0x84, 0x07, 0xC0, 0x0E, 0x00, 0x21, 0x00, 0x81,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x08, 0x80, 0x0E, 0x00,
  0x28, 0x01, 0x88, 0x0C, 0x08, 0x18, 0x08, 0x50, 0x08, 0xA0, 0x0A, 0x40,
  0x0C, 0x80, 0x18, 0x80, 0xC8, 0xFE, 0x08, 0xFE, 0x08, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10, 0x42, 0x08, 0x60, 0x82,
  0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42,
  0x22, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0C, 0x4E, 0x7E, 0x03, 0x00,
  0x90, 0x12, 0x04, 0x20, 0x82, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x55, 0xA0, 0xFC, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1F,
  0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x4C, 0x10,
  0x7C, 0x00, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x3E, 0x08, 0x32, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x03, 0xFF, 0x80, 0x1F, 0x86, 0x04, 0x80, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x81, 0xF8, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x04, 0x7F, 0x80, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x50, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x80, 0x43, 0xFF, 0xF0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x7F, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x00, 0x18, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x50, 0x11, 0xFC, 0x00, 0x07,
  0xC3, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x30, 0xB9, 0x98,
  0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x24, 0x08,
  0x7E, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x00, 0x1E, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x90, 0x11, 0x04, 0x1B, 0x03, 0xE0, 0x82, 0x20, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x08, 0xFE, 0x00, 0x0F, 0x03, 0x0C, 0x40,
  0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20,
  0x51, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x7F,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x68, 0x00, 0x00, 0x00, 0x24, 0x94, 0x80,
  0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x7C, 0x41, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x08, 0x10, 0x00,
  0x42, 0x00, 0x02, 0x20, 0x00, 0x14, 0x0F, 0xE1, 0x41, 0x02, 0x14, 0x20,
  0x21, 0x82, 0x02, 0x18, 0x20, 0x21, 0x82, 0x04, 0x18, 0x20, 0x41, 0x82,
  0x04, 0x18, 0x20, 0xA1, 0x41, 0xF3, 0xE4, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x60, 0x01, 0x78, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x82, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x06, 0x00, 0x08, 0xFA, 0x10,
  0x32, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x9F, 0xF2,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0B, 0xFE,
  0x00, 0x07, 0xF0, 0x40, 0x4C, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFE, 0xFE, 0x04, 0x0E, 0x20,
  0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24,
  0x06, 0x3F, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x03, 0xF8, 0x18, 0x08, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x20,
  0x04, 0x3F, 0xF0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x18, 0x9C, 0x80, 0x28, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x88,
  0x09, 0x00, 0xB0, 0x0C, 0x80, 0x88, 0x08, 0x40, 0x82, 0x08, 0x10, 0x81,
  0x08, 0x08, 0x80, 0x48, 0x04, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x09, 0x90, 0x09, 0x90,
  0x09, 0x88, 0x11, 0x88, 0x11, 0x88, 0x21, 0x84, 0x21, 0x84, 0x21, 0x82,
  0x41, 0x82, 0x41, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x84, 0x18, 0x41,
  0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x58, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x10, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x10, 0x08, 0x0F, 0xF0, 0xFC, 0x20, 0xE8, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x2F, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x10, 0x08, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0xF4, 0x10, 0x72, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x14,
  0x02, 0x80, 0x50, 0x33, 0xF8, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x04,
  0x80, 0x50, 0x0A, 0x00, 0x80, 0x0F, 0xC3, 0x02, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0xFF, 0x80, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x08, 0x80,
  0x41, 0xFE, 0x00, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x84, 0x01, 0x08, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x84, 0x00, 0x88, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x06,
  0x00, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x04, 0x80,
  0xA0, 0x24, 0x05, 0x01, 0x20, 0x48, 0x09, 0x02, 0x40, 0x84, 0x11, 0x04,
  0x20, 0x88, 0x21, 0x08, 0x42, 0x08, 0x41, 0x10, 0x22, 0x08, 0x81, 0x20,
  0x44, 0x09, 0x02, 0x40, 0x28, 0x0A, 0x01, 0x40, 0x50, 0x0C, 0x03, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x41,
  0x04, 0x04, 0x20, 0x22, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x01, 0x40, 0x09,
  0x00, 0x88, 0x08, 0x20, 0x40, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x02,
  0x80, 0x0C, 0x00, 0x50, 0x04, 0x40, 0x22, 0x02, 0x08, 0x20, 0x41, 0x01,
  0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x3F, 0xFE, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0xE0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x11, 0x00, 0x88, 0x08,
  0x20, 0x41, 0x04, 0x04, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x10, 0xFF,
  0xC0, 0x84, 0x21, 0x1F, 0x18, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFC,
  0xC1, 0x40, 0x60, 0x18, 0x06, 0x01, 0x40, 0xCF, 0xD0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0x8A, 0x04, 0xC0, 0x2C, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x2C, 0x02,
  0xA0, 0x49, 0xF8, 0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x01, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x47, 0xCB, 0x05, 0x40, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0D, 0x02, 0x9F, 0x90, 0x1F,
  0x08, 0x24, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x0F, 0xF0, 0x07, 0x8C, 0x04, 0x02, 0x01, 0x00, 0x83,
  0xF8, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x1F, 0x2C, 0x15, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0A, 0x7E, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0A, 0x01, 0x3F, 0xC0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x27, 0xE5, 0x02, 0xC0, 0x50, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0xC7, 0xFF, 0xE0, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x0A, 0x04, 0x82, 0x20, 0x88, 0x42, 0x20, 0x90, 0x2A, 0x0C, 0x42, 0x08,
  0x82, 0x20, 0x48, 0x0A, 0x01, 0xFF, 0xFF, 0xF0, 0x9F, 0x1F, 0x28, 0x28,
  0x2C, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06,
  0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80,
  0x40, 0x60, 0x10, 0x10, 0x9F, 0x94, 0x0B, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x24, 0x04, 0x7F, 0x00, 0x9F, 0x8A, 0x04, 0xC0,
  0x2C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x2C, 0x02, 0xA0, 0x49, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x0F, 0x93, 0x05, 0x40, 0x34, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x9F, 0x43, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x3F, 0x90, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x03, 0x80, 0x1C, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0xBF, 0xC0, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x34, 0x0A, 0x7E, 0x40, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41,
  0x08, 0x20, 0x84, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x40, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x14, 0x14, 0x12, 0x11, 0x09,
  0x08, 0x84, 0x44, 0x44, 0x22, 0x12, 0x12, 0x09, 0x05, 0x05, 0x02, 0x82,
  0x81, 0x40, 0x80, 0x40, 0x40, 0x20, 0x80, 0x48, 0x09, 0x02, 0x10, 0x81,
  0x20, 0x14, 0x03, 0x00, 0x60, 0x12, 0x02, 0x20, 0x84, 0x20, 0x44, 0x05,
  0x00, 0xC0, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41, 0x08, 0x20,
  0x84, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x70, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xF0,
  0x06, 0x30, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x86, 0x06, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x30,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0x7E, 0x18,
  0x1E,
};

const GFXglyph NotoSans_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 4, 7, 8, 2, -19 },
  { 10, 15, 19, 17, 1, -19 },
  { 46, 10, 22, 15, 2, -20 },
  { 74, 17, 19, 21, 2, -19 },
  { 115, 15, 19, 18, 2, -19 },
  { 151, 1, 7, 4, 2, -19 },
  { 152, 5, 23, 7, 1, -19 },
  { 167, 5, 23, 7, 1, -19 },
  { 182, 11, 11, 14, 2, -20 },
  { 198, 12, 12, 15, 1, -15 },
  { 216, 2, 6, 5, 1, -3 },
  { 218, 6, 1, 8, 1, -8 },
  { 219, 2, 1, 6, 2, -1 },
  { 220, 8, 19, 8, 0, -19 },
  { 239, 11, 19, 15, 2, -19 },
  { 266, 5, 19, 15, 3, -19 },
  { 278, 11, 19, 15, 2, -19 },
  { 305, 12, 19, 15, 1, -19 },
  { 334, 14, 19, 15, 1, -19 },
  { 368, 11, 19, 15, 2, -19 },
  { 395, 11, 19, 15, 2, -19 },
  { 422, 11, 19, 15, 2, -19 },
  { 449, 11, 19, 15, 2, -19 },
  { 476, 12, 19, 15, 1, -19 },
  { 505, 2, 14, 6, 2, -14 },
  { 509, 3, 17, 6, 1, -14 },
  { 516, 12, 11, 15, 1, -15 },
  { 533, 12, 6, 15, 1, -12 },
  { 542, 12, 11, 15, 1, -15 },
  { 559, 9, 19, 11, 1, -19 },
  { 581, 20, 21, 23, 1, -18 },
  { 634, 15, 19, 15, 0, -19 },
  { 670, 11, 19, 16, 3, -19 },
  { 697, 13, 19, 16, 2, -19 },
  { 728, 13, 19, 18, 3, -19 },
  { 759, 10, 19, 14, 3, -19 },
  { 783, 10, 19, 13, 3, -19 },
  { 807, 15, 19, 19, 2, -19 },
  { 843, 13, 19, 18, 3, -19 },
  { 874, 4, 19, 7, 2, -19 },
  { 884, 6, 24, 6, -3, -19 },
  { 902, 12, 19, 15, 3, -19 },
  { 931, 10, 19, 13, 3, -19 },
  { 955, 16, 19, 22, 3, -19 },
  { 993, 12, 19, 18, 3, -19 },
  { 1022, 16, 19, 20, 2, -19 },
  { 1060, 10, 19, 15, 3, -19 },
  { 1084, 16, 23, 20, 2, -19 },
  { 1130, 11, 19, 15, 3, -19 },
  { 1157, 12, 19, 14, 1, -19 },
  { 1186, 13, 19, 13, 0, -19 },
  { 1217, 14, 19, 19, 2, -19 },
  { 1251, 15, 19, 15, 0, -19 },
  { 1287, 21, 19, 23, 1, -19 },
  { 1337, 13, 19, 13, 0, -19 },
  { 1368, 13, 19, 13, 0, -19 },
  { 1399, 13, 19, 15, 1, -19 },
  { 1430, 5, 23, 8, 2, -19 },
  { 1445, 8, 19, 8, 0, -19 },
  { 1464, 5, 23, 8, 1, -19 },
  { 1479, 13, 12, 15, 1, -19 },
  { 1499, 10, 1, 10, 0, 2 },
  { 1501, 4, 4, 6, 1, -20 },
  { 1503, 10, 14, 13, 1, -14 },
  { 1521, 12, 20, 15, 2, -20 },
  { 1551, 9, 14, 12, 2, -14 },
  { 1567, 11, 20, 15, 2, -20 },
  { 1595, 10, 14, 14, 2, -14 },
  { 1613, 9, 20, 7, 0, -20 },
  { 1636, 11, 20, 15, 2, -14 },
  { 1664, 11, 20, 15, 2, -20 },
  { 1692, 1, 19, 5, 2, -19 },
  { 1695, 4, 25, 5, -1, -19 },
  { 1708, 10, 20, 12, 2, -20 },
  { 1733, 1, 20, 5, 2, -20 },
  { 1736, 18, 14, 22, 2, -14 },
  { 1768, 11, 14, 15, 2, -14 },
  { 1788, 11, 14, 15, 2, -14 },
  { 1808, 12, 20, 15, 2, -14 },
  { 1838, 12, 20, 15, 1, -14 },
  { 1868, 7, 14, 10, 2, -14 },
  { 1881, 10, 14, 12, 1, -14 },
  { 1899, 8, 17, 8, 0, -17 },
  { 1916, 11, 14, 15, 2, -14 },
  { 1936, 11, 14, 11, 0, -14 },
  { 1956, 17, 14, 18, 0, -14 },
  { 1986, 11, 14, 12, 1, -14 },
  { 2006, 11, 20, 11, 0, -14 },
  { 2034, 10, 14, 12, 1, -14 },
  { 2052, 7, 23, 9, 1, -19 },
  { 2073, 1, 27, 14, 6, -20 },
  { 2077, 7, 23, 9, 1, -19 },
  { 2098, 12, 2, 15, 1, -10 },
};

const GFXfont NotoSans_Thin26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin26pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_THIN26PT7B_H_
