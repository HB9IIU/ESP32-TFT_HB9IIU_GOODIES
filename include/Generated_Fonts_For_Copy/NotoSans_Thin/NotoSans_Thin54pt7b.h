#ifndef _NOTOSANS_THIN54PT7B_H_
#define _NOTOSANS_THIN54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x02, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x20, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x80, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x97,
  0xF0, 0x70, 0x40, 0xE3, 0x01, 0x00, 0x08, 0x04, 0x00, 0x60, 0x10, 0x01,
  0x00, 0x40, 0x04, 0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x10, 0x01, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x18, 0x04, 0x00, 0x30, 0x10, 0x00, 0x60, 0x40,
  0x00, 0xC1, 0x00, 0x01, 0xC4, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x04, 0xF0, 0x00, 0x10, 0x60, 0x00, 0x40, 0xC0, 0x01,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x10, 0x01, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0xC0,
  0x04, 0x02, 0x00, 0x10, 0x1A, 0x00, 0x41, 0xC7, 0x81, 0x1E, 0x07, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xE0, 0x00, 0x0C, 0x00, 0xE3, 0x80, 0x00, 0x40, 0x0C, 0x06, 0x00,
  0x06, 0x00, 0x40, 0x10, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x40, 0x01, 0x80, 0x04, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x20, 0x00,
  0x60, 0x03, 0x03, 0x00, 0x03, 0x00, 0x18, 0x10, 0x00, 0x18, 0x00, 0xC1,
  0x81, 0xC0, 0x40, 0x06, 0x18, 0x3F, 0x82, 0x00, 0x20, 0x87, 0x06, 0x18,
  0x01, 0x0C, 0x30, 0x18, 0xC0, 0x18, 0x43, 0x00, 0x42, 0x00, 0x86, 0x10,
  0x03, 0x18, 0x0C, 0x21, 0x80, 0x08, 0x71, 0xC3, 0x0C, 0x00, 0x40, 0xF8,
  0x10, 0x60, 0x02, 0x00, 0x01, 0x82, 0x00, 0x18, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x00, 0x80, 0x80, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x00, 0x40,
  0x20, 0x01, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x40, 0x00, 0x70, 0x60, 0x06, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x60, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x08,
  0x60, 0x06, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x04, 0x60, 0x00, 0x60, 0x02,
  0x30, 0x00, 0x18, 0x03, 0x10, 0x00, 0x06, 0x01, 0x18, 0x00, 0x01, 0x81,
  0x8C, 0x00, 0x00, 0x60, 0x86, 0x00, 0x00, 0x18, 0xC3, 0x00, 0x00, 0x06,
  0xC0, 0x80, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x78, 0x08, 0x00, 0x00, 0x66, 0x06, 0x00, 0x00, 0xE1, 0x81, 0xC0, 0x00,
  0xC0, 0x60, 0x38, 0x03, 0xC0, 0x18, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x06, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x40, 0x08, 0x01, 0xF0, 0x10, 0x0E, 0x7C, 0x20, 0xF0, 0x0E, 0x4F, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x05, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x83, 0x00, 0x02, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x18,
  0xC4, 0x63, 0x18, 0x84, 0x62, 0x11, 0x88, 0x00, 0xFF, 0xF8, 0xFC, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC1, 0xE0, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x06, 0x81, 0x90, 0xE2,
  0x30, 0x4C, 0x0F, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0xFE, 0x00, 0x07, 0x83, 0x80, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0x83, 0xC0, 0x38, 0x00, 0x70, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x30, 0xF8,
  0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x02, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x02, 0x00, 0x02, 0x00, 0x30, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x67, 0xFE, 0x00, 0xFF, 0x0F, 0x80, 0x80, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3C,
  0x00, 0x83, 0xFF, 0xC0, 0x87, 0x00, 0x70, 0x9C, 0x00, 0x18, 0xB0, 0x00,
  0x0C, 0xA0, 0x00, 0x04, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC3, 0xE0, 0x0E, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE7, 0x80, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x70, 0x03, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x83, 0xC0, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x18, 0x20, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x60, 0x00, 0x05,
  0x20, 0x00, 0x09, 0x30, 0x00, 0x19, 0x1C, 0x00, 0x63, 0x07, 0x03, 0xC3,
  0x01, 0xFF, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x07, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x18,
  0xC6, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x42, 0x31, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x0F, 0x8C, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0xFF, 0xE0, 0x04, 0x20, 0x00, 0xE0,
  0x18, 0x01, 0x98, 0x00, 0x60, 0x02, 0x00, 0x64, 0x00, 0x30, 0x00, 0x80,
  0x09, 0x00, 0x18, 0x00, 0x20, 0x02, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xB0,
  0x02, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x80, 0x0E, 0x00, 0x60,
  0x00, 0x20, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x04, 0x00, 0x06,
  0x00, 0x28, 0x01, 0x00, 0x01, 0x80, 0x0A, 0x00, 0x40, 0x00, 0x60, 0x02,
  0x80, 0x10, 0x00, 0x18, 0x00, 0xA0, 0x06, 0x00, 0x06, 0x00, 0x68, 0x01,
  0x80, 0x03, 0x80, 0x13, 0x00, 0x20, 0x00, 0xA0, 0x0C, 0xC0, 0x0C, 0x00,
  0x68, 0x02, 0x10, 0x01, 0x80, 0x33, 0x01, 0x84, 0x00, 0x38, 0x38, 0x61,
  0xC1, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x08, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xFF, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0xF0, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x30, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0x00, 0x80, 0x0F, 0xE0,
  0x80, 0x00, 0x38, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x70, 0x80, 0x07, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x80, 0x01, 0xE0, 0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x70, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80, 0x80,
  0x00, 0xF0, 0x08, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x54, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x43, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x81,
  0xCF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80,
  0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x18, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60, 0x00, 0x80, 0xC0, 0x00, 0x81,
  0x80, 0x00, 0x83, 0x00, 0x00, 0x87, 0x00, 0x00, 0x8D, 0x80, 0x00, 0x98,
  0xC0, 0x00, 0xB0, 0x60, 0x00, 0xE0, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x02, 0xEC, 0x00,
  0x00, 0x01, 0xB9, 0x00, 0x00, 0x00, 0x4E, 0x60, 0x00, 0x00, 0x13, 0x88,
  0x00, 0x00, 0x0C, 0xE3, 0x00, 0x00, 0x02, 0x38, 0xC0, 0x00, 0x01, 0x8E,
  0x10, 0x00, 0x00, 0x43, 0x86, 0x00, 0x00, 0x30, 0xE0, 0x80, 0x00, 0x0C,
  0x38, 0x30, 0x00, 0x02, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x81, 0x00, 0x00,
  0x40, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x08, 0x00, 0x0C, 0x0E, 0x03, 0x00,
  0x02, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xE0, 0x10, 0x00, 0x40, 0x38, 0x06,
  0x00, 0x30, 0x0E, 0x00, 0x80, 0x08, 0x03, 0x80, 0x30, 0x02, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x01, 0x00, 0x40, 0x0E, 0x00, 0x60, 0x30, 0x03,
  0x80, 0x08, 0x08, 0x00, 0xE0, 0x03, 0x02, 0x00, 0x38, 0x00, 0x41, 0x80,
  0x0E, 0x00, 0x18, 0x40, 0x03, 0x80, 0x06, 0x30, 0x00, 0xE0, 0x00, 0x88,
  0x00, 0x38, 0x00, 0x36, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x08, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x08, 0x00, 0x3C, 0x20, 0x00, 0x18, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x48, 0x00, 0x02,
  0x20, 0x00, 0x38, 0x80, 0x03, 0x83, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x80, 0x03, 0xC0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x0F, 0x83, 0xF8, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC8, 0x00, 0x03, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x80, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0,
  0x00, 0x04, 0xC0, 0x00, 0x34, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00, 0x31, 0x00, 0x00, 0x86,
  0x00, 0x06, 0x30, 0x00, 0x30, 0x40, 0x00, 0x86, 0x00, 0x06, 0x08, 0x00,
  0x10, 0x40, 0x00, 0x81, 0x80, 0x06, 0x08, 0x00, 0x30, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x10, 0x00, 0x80, 0x40,
  0x04, 0x02, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0x40, 0x00, 0xC3, 0x00, 0x01,
  0x08, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x10, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x20, 0x0C,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x08, 0x03, 0x00, 0x06, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xFE,
  0x00, 0xFC, 0x78, 0x38, 0x00, 0xC2, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x03, 0xF0, 0x11,
  0xE0, 0x01, 0x30, 0x00, 0x16, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x5C, 0x00, 0x09, 0x60, 0x01, 0x13, 0x00, 0x61, 0x1F, 0xFC, 0x10, 0x0C,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x0F, 0xF0, 0x10, 0x78, 0x78, 0x23, 0x00, 0x18, 0x4C, 0x00, 0x18, 0xB0,
  0x00, 0x19, 0x40, 0x00, 0x1B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x4A, 0x00, 0x01, 0x96,
  0x00, 0x06, 0x26, 0x00, 0x18, 0x47, 0x00, 0xE0, 0x83, 0xFF, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x83, 0xC0, 0xE0, 0x02, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x03,
  0x03, 0xC1, 0xC3, 0x06, 0x00, 0x33, 0x0C, 0x00, 0x1B, 0x18, 0x00, 0x0B,
  0x30, 0x00, 0x0F, 0x20, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x07, 0x60, 0x00, 0x07, 0x20, 0x00, 0x07, 0x30, 0x00, 0x0F,
  0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x01, 0xFF, 0x83,
  0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x87, 0x80, 0x1C, 0x01, 0x80,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x10, 0x3C, 0x00, 0xE0,
  0x1F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x40, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x87, 0xFF, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0x03, 0xE3, 0xE3, 0x06, 0x00, 0x33, 0x0C, 0x00, 0x1B, 0x18, 0x00,
  0x0B, 0x30, 0x00, 0x07, 0x20, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x20, 0x00, 0x07, 0x30, 0x00,
  0x0B, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x01, 0xFF,
  0x83, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x38, 0x00, 0x30, 0x1F, 0xC7,
  0xE0, 0x01, 0xFF, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x0F, 0xF0, 0x43, 0xE1, 0xE2, 0x30, 0x01, 0x93, 0x00, 0x06, 0xB0, 0x00,
  0x15, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x7F, 0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x4C, 0xE3, 0xF0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80,
  0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x18, 0x00,
  0x83, 0x00, 0x08, 0x70, 0x00, 0x8D, 0x80, 0x09, 0x8C, 0x00, 0xB0, 0x40,
  0x0A, 0x06, 0x00, 0xC0, 0x30, 0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00,
  0xC0, 0x80, 0x06, 0x08, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80,
  0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x81, 0xFC, 0x00, 0xFE, 0x04, 0x3C, 0x78, 0x1E, 0x1C, 0x27, 0x00,
  0x61, 0x80, 0x31, 0x20, 0x01, 0x18, 0x00, 0xCA, 0x00, 0x0D, 0x80, 0x03,
  0x70, 0x00, 0x28, 0x00, 0x0B, 0x00, 0x01, 0xC0, 0x00, 0x58, 0x00, 0x0C,
  0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x02, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x02,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x01, 0x00,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x80, 0xFF, 0x04, 0x3C, 0x1E, 0x23, 0x00, 0x19,
  0x30, 0x00, 0x6B, 0x00, 0x01, 0x50, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80,
  0x01, 0xE1, 0xF0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x80, 0xFF, 0x01, 0x07, 0x87,
  0x82, 0x38, 0x01, 0x84, 0xC0, 0x01, 0x89, 0x00, 0x01, 0x96, 0x00, 0x01,
  0xA8, 0x00, 0x01, 0x70, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xB8, 0x00,
  0x03, 0x50, 0x00, 0x06, 0xB0, 0x00, 0x19, 0x30, 0x00, 0x62, 0x70, 0x01,
  0x84, 0x38, 0x0E, 0x08, 0x3F, 0xF8, 0x10, 0x02, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x03,
  0xC1, 0xC3, 0x06, 0x00, 0x73, 0x0C, 0x00, 0x13, 0x18, 0x00, 0x0B, 0x30,
  0x00, 0x0F, 0x20, 0x00, 0x07, 0x60, 0x00, 0x07, 0x40, 0x00, 0x07, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x40,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x20, 0x00, 0x0F, 0x30, 0x00, 0x0B, 0x10,
  0x00, 0x1B, 0x0C, 0x00, 0x33, 0x06, 0x00, 0xE3, 0x03, 0xFF, 0x83, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x81, 0xFE, 0x1E, 0x78, 0xC0, 0x24, 0x00, 0xA0, 0x02, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0x7E, 0x18, 0x00,
  0x23, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x80, 0x00,
  0x6F, 0x00, 0x18, 0x3F, 0xFF, 0x00, 0x14, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x1C, 0x08, 0x1F, 0xF0, 0x02, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x05,
  0x60, 0x00, 0x34, 0xC0, 0x00, 0x91, 0x80, 0x0C, 0x43, 0x00, 0xE1, 0x07,
  0xFF, 0x04, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x20, 0x00,
  0x80, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80, 0x08, 0x01, 0x80, 0x30,
  0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00,
  0x22, 0x00, 0x00, 0x64, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x0D, 0x00, 0x03, 0xC0, 0x01, 0x30, 0x00, 0x58, 0x00, 0x26, 0x00,
  0x09, 0x00, 0x0C, 0x40, 0x03, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x21,
  0x80, 0x08, 0x40, 0x04, 0x30, 0x03, 0x08, 0x01, 0x82, 0x00, 0x41, 0x80,
  0x20, 0x60, 0x08, 0x10, 0x04, 0x0C, 0x03, 0x02, 0x00, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x10, 0x08, 0x04, 0x04, 0x03, 0x03, 0x00, 0x80, 0x80, 0x60,
  0x40, 0x18, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x20, 0x80,
  0x18, 0x40, 0x06, 0x10, 0x01, 0x08, 0x00, 0x46, 0x00, 0x23, 0x00, 0x08,
  0xC0, 0x06, 0x40, 0x01, 0x90, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0x40, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x80, 0x80, 0x03, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x10, 0x01, 0x80, 0x60, 0x01, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x64, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x00, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x10, 0x08, 0x00, 0x30, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x23, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x13, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00,
  0x60, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x02, 0x03, 0x00,
  0x04, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x20, 0x00, 0x18, 0x40, 0x00,
  0x31, 0x80, 0x00, 0x22, 0x00, 0x00, 0x64, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x8E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x7C, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x01,
  0xC0, 0x3E, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0xB0, 0x1C, 0x00, 0xF0,
  0x03, 0xC1, 0xD0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 39, 12, 5, -39 },
  { 11, 9, 14, 17, 4, -39 },
  { 27, 31, 39, 35, 2, -39 },
  { 179, 22, 44, 31, 3, -41 },
  { 300, 37, 40, 43, 3, -39 },
  { 485, 33, 40, 38, 3, -39 },
  { 650, 1, 14, 9, 4, -39 },
  { 652, 10, 48, 14, 2, -39 },
  { 712, 10, 48, 14, 2, -39 },
  { 772, 23, 22, 30, 3, -41 },
  { 836, 25, 24, 31, 3, -31 },
  { 911, 5, 13, 10, 2, -6 },
  { 920, 13, 1, 17, 2, -15 },
  { 922, 2, 3, 12, 5, -3 },
  { 923, 16, 39, 17, 1, -39 },
  { 1001, 24, 40, 31, 3, -39 },
  { 1121, 11, 39, 31, 6, -39 },
  { 1175, 24, 39, 31, 3, -39 },
  { 1292, 24, 40, 31, 3, -39 },
  { 1412, 29, 39, 31, 1, -39 },
  { 1554, 23, 40, 31, 4, -39 },
  { 1669, 24, 40, 31, 4, -39 },
  { 1789, 25, 39, 31, 3, -39 },
  { 1911, 24, 40, 31, 3, -39 },
  { 2031, 24, 40, 31, 3, -39 },
  { 2151, 2, 29, 12, 5, -29 },
  { 2159, 5, 36, 12, 2, -29 },
  { 2182, 25, 25, 31, 3, -32 },
  { 2261, 25, 12, 31, 3, -25 },
  { 2299, 25, 25, 31, 3, -32 },
  { 2378, 18, 39, 22, 2, -39 },
  { 2466, 42, 43, 47, 3, -38 },
  { 2692, 31, 39, 31, 0, -39 },
  { 2844, 24, 39, 33, 6, -39 },
  { 2961, 28, 40, 33, 3, -39 },
  { 3101, 28, 39, 37, 6, -39 },
  { 3238, 20, 39, 30, 6, -39 },
  { 3336, 20, 39, 27, 6, -39 },
  { 3434, 32, 40, 39, 3, -39 },
  { 3594, 27, 39, 38, 6, -39 },
  { 3726, 9, 39, 15, 3, -39 },
  { 3770, 12, 48, 12, -5, -39 },
  { 3842, 24, 39, 30, 6, -39 },
  { 3959, 20, 39, 27, 6, -39 },
  { 4057, 34, 39, 45, 6, -39 },
  { 4223, 26, 39, 38, 6, -39 },
  { 4350, 34, 40, 41, 3, -39 },
  { 4520, 22, 39, 31, 6, -39 },
  { 4628, 34, 48, 41, 3, -39 },
  { 4832, 24, 39, 31, 6, -39 },
  { 4949, 23, 40, 29, 3, -39 },
  { 5064, 27, 39, 27, 0, -39 },
  { 5196, 28, 40, 38, 5, -39 },
  { 5336, 30, 39, 30, 0, -39 },
  { 5483, 43, 39, 47, 2, -39 },
  { 5693, 28, 39, 27, 0, -39 },
  { 5830, 27, 39, 27, 0, -39 },
  { 5962, 27, 39, 31, 2, -39 },
  { 6094, 11, 48, 17, 5, -39 },
  { 6160, 16, 39, 17, 1, -39 },
  { 6238, 11, 48, 17, 1, -39 },
  { 6304, 26, 24, 31, 2, -39 },
  { 6382, 21, 1, 21, 0, 5 },
  { 6385, 9, 8, 13, 2, -41 },
  { 6394, 20, 30, 28, 3, -29 },
  { 6469, 23, 42, 31, 5, -41 },
  { 6590, 21, 30, 25, 3, -29 },
  { 6669, 24, 42, 31, 3, -41 },
  { 6795, 23, 30, 29, 3, -29 },
  { 6882, 17, 41, 15, 1, -41 },
  { 6970, 24, 42, 31, 3, -29 },
  { 7096, 21, 41, 31, 5, -41 },
  { 7204, 3, 39, 11, 4, -39 },
  { 7219, 10, 52, 11, -3, -39 },
  { 7284, 20, 41, 25, 5, -41 },
  { 7387, 1, 41, 11, 5, -41 },
  { 7393, 37, 29, 46, 5, -29 },
  { 7528, 21, 29, 31, 5, -29 },
  { 7605, 25, 30, 31, 3, -29 },
  { 7699, 23, 42, 31, 5, -29 },
  { 7820, 24, 42, 31, 3, -29 },
  { 7946, 14, 29, 20, 5, -29 },
  { 7997, 20, 30, 25, 2, -29 },
  { 8072, 15, 37, 17, 1, -36 },
  { 8142, 22, 30, 31, 4, -29 },
  { 8225, 23, 29, 23, 0, -29 },
  { 8309, 35, 28, 37, 1, -28 },
  { 8432, 23, 29, 26, 1, -29 },
  { 8516, 23, 42, 23, 0, -29 },
  { 8637, 20, 29, 25, 2, -29 },
  { 8710, 15, 48, 18, 1, -39 },
  { 8800, 1, 55, 29, 14, -41 },
  { 8807, 15, 48, 18, 2, -39 },
  { 8897, 25, 4, 31, 3, -21 },
};

const GFXfont NotoSans_Thin54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin54pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_THIN54PT7B_H_
