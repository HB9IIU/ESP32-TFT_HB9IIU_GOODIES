#ifndef _NOTOSANS_THIN9PT7B_H_
#define _NOTOSANS_THIN9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x28, 0xB5, 0x3E, 0x51, 0x40, 0x7B, 0x26, 0xFA, 0x83,
  0x4D, 0x3F, 0xA5, 0x55, 0xC0, 0x45, 0x28, 0x8A, 0xCB, 0xE0, 0xC0, 0x6A,
  0xA4, 0xD5, 0x5C, 0x5D, 0x50, 0x27, 0xC8, 0x40, 0xC0, 0xE0, 0x00, 0x29,
  0x29, 0x00, 0x69, 0x99, 0x99, 0xE0, 0xD5, 0x50, 0xC4, 0x95, 0x38, 0x69,
  0x16, 0x11, 0xF0, 0x31, 0x95, 0x27, 0x88, 0xE8, 0xE1, 0x1E, 0x68, 0x8E,
  0x99, 0xE0, 0xF2, 0x24, 0x48, 0x69, 0x96, 0x99, 0xE0, 0x64, 0xA3, 0x17,
  0x85, 0xC0, 0x80, 0x8C, 0x3E, 0x08, 0x30, 0xFF, 0xC0, 0xE0, 0xCD, 0x80,
  0xC4, 0x94, 0x10, 0x7E, 0xB6, 0x9D, 0x3B, 0xE8, 0x0F, 0x00, 0x22, 0x94,
  0xE8, 0xC4, 0xF9, 0xE9, 0x9F, 0x78, 0x88, 0x88, 0xF0, 0xF4, 0x63, 0x18,
  0xF8, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x7C, 0x21, 0x68, 0xC7, 0xE0,
  0x99, 0xF9, 0x99, 0xFC, 0x55, 0x56, 0xBC, 0xCA, 0xA9, 0x92, 0x49, 0xC0,
  0x86, 0x3C, 0xF5, 0xA6, 0x90, 0x99, 0xDB, 0x99, 0x74, 0x63, 0x18, 0xC7,
  0xC0, 0xF9, 0xBC, 0x88, 0x74, 0x63, 0x18, 0xC7, 0xC2, 0x08, 0xF9, 0x9E,
  0xA9, 0x78, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x8C, 0x63, 0x18,
  0xF8, 0x8C, 0x54, 0xA5, 0x10, 0x91, 0x9A, 0x5A, 0x6A, 0x24, 0x24, 0x92,
  0x88, 0xC5, 0x44, 0x9A, 0x98, 0x42, 0x10, 0x78, 0x88, 0x44, 0x7C, 0xEA,
  0xAC, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x22, 0x93, 0x10, 0xF0, 0x90, 0x71,
  0x79, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xF2, 0x4E, 0x27, 0xDB, 0x78, 0xF7,
  0xCE, 0x6B, 0x24, 0x90, 0xF6, 0xDE, 0x78, 0x93, 0xDB, 0x68, 0x7C, 0x7F,
  0x92, 0xE9, 0xA8, 0xFE, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA, 0xE9, 0x99,
  0xE0, 0xE9, 0x99, 0xE8, 0x80, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x78,
  0x61, 0xF0, 0x9E, 0x48, 0xC0, 0xB6, 0xDE, 0x99, 0xA6, 0x40, 0x96, 0x5B,
  0x52, 0x48, 0x96, 0x26, 0x90, 0x99, 0xA6, 0x44, 0xC0, 0x72, 0x24, 0xF0,
  0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph NotoSans_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 6, 7, 7, 1, -7 },
  { 17, 5, 7, 6, 1, -7 },
  { 22, 1, 2, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 2, 7, 2, 0, -6 },
  { 27, 3, 4, 5, 1, -7 },
  { 29, 5, 4, 5, 0, -5 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 3, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 1, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 7, 5, 1, -7 },
  { 42, 2, 6, 5, 1, -6 },
  { 44, 3, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 7, 5, 1, -7 },
  { 62, 4, 6, 5, 1, -6 },
  { 65, 4, 7, 5, 1, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 1, 5, 2, 1, -5 },
  { 75, 1, 6, 2, 0, -5 },
  { 76, 5, 4, 5, 0, -5 },
  { 79, 5, 2, 5, 0, -4 },
  { 81, 5, 4, 5, 0, -5 },
  { 84, 3, 7, 4, 0, -7 },
  { 87, 7, 7, 8, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 6, 1, -6 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 5, 6, 6, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 4, 1, -6 },
  { 115, 5, 7, 6, 1, -7 },
  { 120, 4, 6, 6, 1, -6 },
  { 123, 1, 6, 3, 1, -6 },
  { 124, 2, 8, 2, -1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 6, 6, 8, 1, -6 },
  { 137, 4, 6, 6, 1, -6 },
  { 140, 5, 7, 7, 1, -7 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 5, 9, 7, 1, -7 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 4, 7, 5, 0, -7 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 6, 1, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 8, 6, 8, 0, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 2, 7, 3, 1, -6 },
  { 193, 3, 6, 3, 0, -6 },
  { 196, 2, 7, 3, 0, -6 },
  { 198, 5, 4, 5, 0, -6 },
  { 201, 4, 1, 4, 0, 0 },
  { 202, 2, 2, 2, 0, -7 },
  { 203, 4, 5, 5, 0, -5 },
  { 206, 4, 7, 5, 1, -7 },
  { 210, 3, 5, 4, 1, -5 },
  { 212, 3, 7, 5, 1, -7 },
  { 215, 3, 5, 5, 1, -5 },
  { 217, 3, 7, 2, 0, -7 },
  { 220, 3, 7, 5, 1, -5 },
  { 223, 3, 7, 5, 1, -7 },
  { 226, 1, 6, 2, 0, -6 },
  { 227, 1, 8, 2, 0, -6 },
  { 228, 3, 7, 4, 1, -7 },
  { 231, 1, 7, 2, 0, -7 },
  { 232, 6, 5, 8, 1, -5 },
  { 236, 3, 5, 5, 1, -5 },
  { 238, 4, 5, 5, 1, -5 },
  { 241, 4, 7, 5, 1, -5 },
  { 245, 4, 7, 5, 0, -5 },
  { 249, 2, 5, 3, 1, -5 },
  { 251, 4, 5, 4, 0, -5 },
  { 254, 3, 6, 3, 0, -6 },
  { 257, 3, 5, 5, 1, -5 },
  { 259, 4, 5, 4, 0, -5 },
  { 262, 6, 5, 6, 0, -5 },
  { 266, 4, 5, 4, 0, -5 },
  { 269, 4, 7, 4, 0, -5 },
  { 273, 4, 5, 4, 0, -5 },
  { 276, 3, 7, 3, 0, -6 },
  { 279, 1, 9, 5, 2, -7 },
  { 281, 3, 7, 3, 0, -6 },
  { 284, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Thin9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin9pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_THIN9PT7B_H_
