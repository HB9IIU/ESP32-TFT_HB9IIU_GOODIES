#ifndef _NOTOSANS_THIN71PT7B_H_
#define _NOTOSANS_THIN71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xF6, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x60,
  0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xB0, 0x05, 0x80, 0x2C, 0x01,
  0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xB0, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0x86, 0x0F, 0xC1, 0xC0, 0x60, 0x1C, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x60, 0x00, 0x01, 0xE6, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x06, 0x78, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x60, 0x0E, 0x00, 0x06, 0x01, 0xC8, 0x00, 0x60, 0x38, 0xF0, 0x06, 0x0F,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x30, 0x1F, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x7F,
  0xF0, 0x60, 0x00, 0x60, 0x60, 0xE0, 0x38, 0x60, 0x00, 0x60, 0xC0, 0xC0,
  0x18, 0x60, 0x00, 0xC0, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC1, 0x83, 0x00,
  0x0C, 0x30, 0x01, 0xC1, 0x83, 0x00, 0x06, 0x18, 0x01, 0x83, 0x03, 0x00,
  0x06, 0x1C, 0x03, 0x03, 0x06, 0x00, 0x06, 0x0F, 0x9E, 0x06, 0x06, 0x00,
  0x03, 0x03, 0xFC, 0x0E, 0x06, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x00, 0x01, 0x86, 0x00, 0x01, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x00, 0x61, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x03, 0x04, 0x00, 0x00, 0x01, 0x80, 0x61, 0x80, 0x00, 0x00, 0x18,
  0x18, 0x30, 0x00, 0x00, 0x01, 0x83, 0x06, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x60, 0x00, 0x00, 0x01, 0xB0, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x39, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x18, 0x07, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x18, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x38, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x40, 0x1F, 0x1F, 0x01, 0x03,
  0xF0, 0x0F, 0x84, 0x3E, 0x00, 0x03, 0xD7, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x8C,
  0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3B,
  0x00, 0xE3, 0x01, 0xC3, 0x03, 0x83, 0x0E, 0x03, 0x1C, 0x03, 0x78, 0x03,
  0xE0, 0x03, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0x80, 0x0F, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x03, 0xFF, 0x80, 0x30, 0x1F,
  0xFF, 0xC0, 0x60, 0xF0, 0x01, 0xE0, 0xC7, 0x80, 0x00, 0xE1, 0x9C, 0x00,
  0x00, 0x63, 0x70, 0x00, 0x00, 0x66, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x1F, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x1A, 0x30, 0x00, 0x00,
  0x1A, 0x38, 0x00, 0x00, 0x32, 0x18, 0x00, 0x00, 0x62, 0x0E, 0x00, 0x01,
  0xC6, 0x07, 0x00, 0x07, 0x86, 0x03, 0xF0, 0x7E, 0x06, 0x00, 0x7F, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x18, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x60, 0x0C, 0x3C, 0x78,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x0C,
  0x18, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0x0F, 0xC0, 0xE0, 0x00, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x30,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x19, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x33, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0xB0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x07, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x58, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0xB0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x06, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x1B, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x66, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0x1C, 0x00, 0x02, 0xC0, 0x03, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x80, 0x06, 0x18, 0x00, 0x18, 0x00, 0x31, 0x80,
  0x18, 0x30, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x60, 0x60, 0x00, 0x1F, 0x1F,
  0x03, 0xCF, 0x80, 0x60, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x07, 0xF0, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x0F, 0xE0, 0x30, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x30, 0x00, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFA, 0x00, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x07, 0x00, 0x00, 0x00,
  0x02, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x03,
  0xFE, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0xFB, 0xF0, 0xFF, 0xC0, 0xC0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x01, 0x87, 0x70, 0x00, 0x00,
  0xC7, 0x18, 0x00, 0x00, 0x63, 0x06, 0x00, 0x00, 0x33, 0x03, 0x80, 0x00,
  0x1B, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x0D, 0xEC, 0x00, 0x00, 0x00, 0x00,
  0x6F, 0x30, 0x00, 0x00, 0x00, 0x03, 0x79, 0x80, 0x00, 0x00, 0x00, 0x33,
  0xC6, 0x00, 0x00, 0x00, 0x01, 0x9E, 0x30, 0x00, 0x00, 0x00, 0x18, 0xF1,
  0x80, 0x00, 0x00, 0x00, 0xC7, 0x86, 0x00, 0x00, 0x00, 0x06, 0x3C, 0x30,
  0x00, 0x00, 0x00, 0x61, 0xE0, 0xC0, 0x00, 0x00, 0x03, 0x0F, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x78, 0x38, 0x00, 0x00, 0x01, 0x83, 0xC0, 0xC0, 0x00,
  0x00, 0x0C, 0x1E, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x18, 0x00, 0x00,
  0x06, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x3C, 0x07, 0x00, 0x00, 0x03,
  0x01, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x78, 0x03, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1E,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x18, 0x01, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0x60, 0x03, 0x00, 0x07, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x3C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x60, 0x0C, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x83, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x80, 0x00, 0x31, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xB0, 0x00, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x00, 0x78, 0x60, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x07, 0x80, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x06, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0xC0,
  0xF0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x00,
  0x18, 0x78, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x31, 0xE0, 0x00,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x06, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x07, 0xE0, 0x30, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xF0, 0x30, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0x41, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC1, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x08, 0x00, 0x04, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x3E,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x80, 0xFC, 0x00, 0x10,
  0x78, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0D, 0x60, 0x00, 0x03, 0x2E, 0x00, 0x00, 0x64, 0xE0,
  0x00, 0x38, 0x8E, 0x00, 0x0E, 0x10, 0xF0, 0x0F, 0x02, 0x07, 0xFF, 0xC0,
  0x40, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xF8, 0x01, 0x81, 0xFF,
  0xFE, 0x03, 0x07, 0x80, 0x0E, 0x06, 0x1C, 0x00, 0x0E, 0x0C, 0x60, 0x00,
  0x06, 0x19, 0x80, 0x00, 0x06, 0x36, 0x00, 0x00, 0x0E, 0x6C, 0x00, 0x00,
  0x0C, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xDE, 0x00,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0x06, 0x6C, 0x00, 0x00, 0x18, 0xD8, 0x00,
  0x00, 0x71, 0x98, 0x00, 0x00, 0xC3, 0x18, 0x00, 0x07, 0x06, 0x1C, 0x00,
  0x1C, 0x0C, 0x1E, 0x01, 0xF0, 0x18, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x01,
  0x80, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x10, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x06, 0x00, 0xFF, 0xFE, 0x0C,
  0x07, 0x80, 0x0E, 0x18, 0x1C, 0x00, 0x0E, 0x30, 0x60, 0x00, 0x06, 0x61,
  0x80, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x0D, 0x8C, 0x00, 0x00, 0x0F, 0x30,
  0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x36,
  0x18, 0x00, 0x00, 0xCC, 0x18, 0x00, 0x03, 0x98, 0x1C, 0x00, 0x0E, 0x30,
  0x1F, 0x00, 0xF0, 0x60, 0x0F, 0xFF, 0x80, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80,
  0xF0, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x0C, 0x07,
  0x80, 0x0E, 0x18, 0x1C, 0x00, 0x06, 0x30, 0x60, 0x00, 0x06, 0x61, 0x80,
  0x00, 0x06, 0xC7, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x0F, 0x30, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x0B, 0x1C, 0x00, 0x00, 0x36, 0x18,
  0x00, 0x00, 0xCC, 0x1C, 0x00, 0x03, 0x18, 0x1C, 0x00, 0x1C, 0x30, 0x1F,
  0x00, 0xF0, 0x60, 0x0F, 0xFF, 0x80, 0xC0, 0x01, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0xF8, 0x06, 0x07, 0xFF, 0xF0, 0x30, 0x70, 0x01, 0xE1, 0x8E, 0x00,
  0x03, 0x8C, 0xE0, 0x00, 0x0E, 0x66, 0x00, 0x00, 0x33, 0x60, 0x00, 0x01,
  0xDA, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0C, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x36, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x64, 0x06,
  0x3F, 0xE0, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x06,
  0xC0, 0x00, 0x61, 0x8C, 0x00, 0x0C, 0x61, 0xC0, 0x01, 0x98, 0x18, 0x00,
  0x36, 0x01, 0x80, 0x07, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x60, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x30, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x18, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8C, 0xC0, 0x00,
  0x71, 0x80, 0x00, 0xE6, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x40, 0x00,
  0x0D, 0x80, 0x00, 0x0D, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xB8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x06, 0x07, 0xFF, 0xF0, 0x30, 0x70, 0x01,
  0xE1, 0x86, 0x00, 0x03, 0x8C, 0x60, 0x00, 0x0E, 0x66, 0x00, 0x00, 0x33,
  0x60, 0x00, 0x01, 0xDA, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0xFF, 0xFE, 0x03, 0x07, 0x80, 0x1E,
  0x06, 0x1C, 0x00, 0x0E, 0x0C, 0x60, 0x00, 0x06, 0x19, 0x80, 0x00, 0x06,
  0x33, 0x00, 0x00, 0x06, 0x6C, 0x00, 0x00, 0x0C, 0xD0, 0x00, 0x00, 0x0D,
  0xE0, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x17, 0x00, 0x00,
  0x00, 0x6F, 0x00, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x03, 0xB6, 0x00, 0x00,
  0x06, 0x6C, 0x00, 0x00, 0x1C, 0xCC, 0x00, 0x00, 0x31, 0x9C, 0x00, 0x00,
  0xC3, 0x1C, 0x00, 0x03, 0x06, 0x1C, 0x00, 0x1C, 0x0C, 0x1F, 0x01, 0xF0,
  0x18, 0x0F, 0xFF, 0x80, 0x30, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x0C, 0x07, 0x80, 0x1E, 0x18, 0x1C, 0x00, 0x0E, 0x30, 0x60,
  0x00, 0x06, 0x61, 0x80, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x0D, 0x8C, 0x00,
  0x00, 0x0F, 0x30, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x1B, 0x18,
  0x00, 0x00, 0x76, 0x18, 0x00, 0x00, 0xCC, 0x38, 0x00, 0x07, 0x18, 0x3C,
  0x00, 0x1C, 0x30, 0x1E, 0x01, 0xF0, 0x60, 0x1F, 0xFF, 0x80, 0xC0, 0x03,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x0E, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x02, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x38, 0xFE, 0x00, 0x7C, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x7F,
  0xF0, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x60, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x03, 0x33, 0x80,
  0x00, 0x71, 0x1C, 0x00, 0x1E, 0x10, 0x78, 0x07, 0x81, 0x03, 0xFF, 0xE0,
  0x10, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x43, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x18, 0x00, 0x02,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x02, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xDC, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xC8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 52, 16, 6, -51 },
  { 27, 13, 19, 23, 5, -51 },
  { 58, 42, 51, 46, 2, -51 },
  { 326, 28, 58, 40, 5, -54 },
  { 529, 48, 52, 56, 4, -51 },
  { 841, 43, 52, 50, 4, -51 },
  { 1121, 2, 19, 12, 5, -51 },
  { 1126, 13, 62, 18, 3, -51 },
  { 1227, 12, 62, 18, 3, -51 },
  { 1320, 30, 29, 39, 4, -54 },
  { 1429, 33, 32, 40, 4, -41 },
  { 1561, 6, 17, 13, 3, -8 },
  { 1574, 17, 2, 23, 3, -20 },
  { 1579, 4, 5, 16, 6, -4 },
  { 1582, 21, 51, 23, 1, -51 },
  { 1716, 32, 52, 40, 4, -51 },
  { 1924, 16, 51, 40, 7, -51 },
  { 2026, 31, 51, 40, 4, -51 },
  { 2224, 32, 52, 40, 3, -51 },
  { 2432, 38, 51, 40, 2, -51 },
  { 2675, 31, 52, 40, 5, -51 },
  { 2877, 31, 53, 40, 5, -52 },
  { 3083, 32, 51, 40, 4, -51 },
  { 3287, 31, 52, 40, 5, -51 },
  { 3489, 32, 52, 40, 4, -51 },
  { 3697, 4, 39, 16, 6, -38 },
  { 3717, 7, 47, 16, 3, -38 },
  { 3759, 33, 32, 40, 4, -42 },
  { 3891, 33, 16, 40, 4, -33 },
  { 3957, 33, 32, 40, 4, -42 },
  { 4089, 24, 52, 29, 3, -51 },
  { 4245, 55, 57, 62, 4, -50 },
  { 4637, 41, 51, 41, 0, -51 },
  { 4899, 33, 51, 44, 7, -51 },
  { 5110, 37, 52, 44, 4, -51 },
  { 5351, 38, 51, 49, 7, -51 },
  { 5594, 28, 51, 39, 7, -51 },
  { 5773, 28, 51, 35, 7, -51 },
  { 5952, 41, 53, 51, 4, -52 },
  { 6224, 36, 51, 50, 7, -51 },
  { 6454, 12, 51, 20, 4, -51 },
  { 6531, 16, 63, 16, -7, -51 },
  { 6657, 33, 51, 40, 7, -51 },
  { 6868, 28, 51, 36, 7, -51 },
  { 7047, 45, 51, 59, 7, -51 },
  { 7334, 35, 51, 50, 7, -51 },
  { 7558, 45, 52, 54, 4, -51 },
  { 7851, 30, 51, 41, 7, -51 },
  { 8043, 45, 63, 54, 4, -51 },
  { 8398, 32, 51, 41, 7, -51 },
  { 8602, 31, 52, 39, 4, -51 },
  { 8804, 36, 51, 36, 0, -51 },
  { 9034, 37, 52, 51, 7, -51 },
  { 9275, 40, 51, 40, 0, -51 },
  { 9530, 58, 51, 62, 2, -51 },
  { 9900, 36, 51, 36, 0, -51 },
  { 10130, 36, 51, 36, 0, -51 },
  { 10360, 35, 51, 41, 3, -51 },
  { 10584, 14, 62, 22, 6, -51 },
  { 10693, 21, 51, 23, 1, -51 },
  { 10827, 14, 62, 22, 2, -51 },
  { 10936, 34, 31, 40, 3, -51 },
  { 11068, 28, 2, 28, 0, 6 },
  { 11075, 12, 11, 18, 3, -54 },
  { 11092, 27, 39, 36, 3, -38 },
  { 11224, 31, 55, 41, 6, -54 },
  { 11438, 27, 39, 34, 4, -38 },
  { 11570, 31, 55, 41, 4, -54 },
  { 11784, 30, 39, 38, 4, -38 },
  { 11931, 23, 54, 19, 1, -54 },
  { 12087, 31, 55, 41, 4, -38 },
  { 12301, 29, 54, 41, 6, -54 },
  { 12497, 3, 51, 15, 6, -51 },
  { 12517, 13, 68, 15, -4, -51 },
  { 12628, 27, 54, 32, 6, -54 },
  { 12811, 2, 54, 15, 6, -54 },
  { 12825, 49, 38, 60, 6, -38 },
  { 13058, 29, 38, 41, 6, -38 },
  { 13196, 33, 39, 41, 4, -38 },
  { 13357, 31, 54, 41, 6, -38 },
  { 13567, 31, 54, 41, 4, -38 },
  { 13777, 19, 38, 27, 6, -38 },
  { 13868, 26, 39, 33, 3, -38 },
  { 13995, 20, 48, 23, 1, -47 },
  { 14115, 28, 38, 41, 6, -37 },
  { 14248, 31, 37, 31, 0, -37 },
  { 14392, 47, 37, 49, 1, -37 },
  { 14610, 30, 37, 34, 2, -37 },
  { 14749, 31, 54, 30, 0, -37 },
  { 14959, 26, 37, 32, 3, -37 },
  { 15080, 19, 62, 24, 2, -51 },
  { 15228, 2, 72, 38, 18, -54 },
  { 15246, 19, 62, 24, 3, -51 },
  { 15394, 33, 6, 40, 4, -28 },
};

const GFXfont NotoSans_Thin71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin71pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_THIN71PT7B_H_
