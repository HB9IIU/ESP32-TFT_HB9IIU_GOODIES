#ifndef _NOTOSANS_THIN19PT7B_H_
#define _NOTOSANS_THIN19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x42, 0x08, 0x8F,
  0xFE, 0x22, 0x04, 0x41, 0x08, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x04, 0x20,
  0x84, 0x00, 0x18, 0x6E, 0x88, 0x88, 0x88, 0x48, 0x38, 0x0C, 0x0A, 0x09,
  0x09, 0x09, 0x0A, 0xFC, 0x08, 0x70, 0x24, 0x42, 0x22, 0x11, 0x09, 0x08,
  0x48, 0x42, 0x92, 0x2B, 0x51, 0x51, 0x74, 0x88, 0x28, 0x42, 0x42, 0x11,
  0x11, 0x08, 0x88, 0x38, 0x1E, 0x02, 0x10, 0x41, 0x04, 0x10, 0x21, 0x01,
  0x60, 0x18, 0x02, 0x80, 0x44, 0x28, 0x22, 0x81, 0x48, 0x0C, 0x80, 0xC7,
  0xF3, 0xF8, 0x25, 0x29, 0x24, 0x92, 0x49, 0x12, 0x20, 0x91, 0x22, 0x49,
  0x24, 0x92, 0x92, 0x80, 0x08, 0x08, 0xCB, 0x3C, 0x18, 0x24, 0x22, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0xF0, 0xF0,
  0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x00,
  0x3C, 0x21, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x24, 0x11, 0xF0, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3C,
  0x42, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x3C, 0xC2, 0x01, 0x01, 0x01, 0x01, 0x3E, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFE, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x90, 0x12, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x22, 0xFF, 0x80, 0x80, 0x10, 0x02, 0x00, 0x7F,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x17, 0xF0, 0x0F, 0x18, 0x10, 0x08, 0x08, 0x04, 0x62, 0xC9, 0x82,
  0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0xFF, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x3E,
  0x20, 0x90, 0x50, 0x24, 0x13, 0x10, 0x70, 0x44, 0x41, 0x40, 0x60, 0x30,
  0x14, 0x11, 0xF0, 0x3C, 0x21, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x04, 0x85,
  0x3C, 0x80, 0x80, 0x40, 0x20, 0x27, 0xE0, 0x80, 0x40, 0x40, 0x00, 0xAA,
  0x01, 0x83, 0x06, 0x0C, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x30, 0xE1, 0x80, 0xF8,
  0x10, 0x41, 0x04, 0x10, 0x84, 0x20, 0x84, 0x00, 0x00, 0x80, 0x1F, 0xF0,
  0x40, 0x11, 0x00, 0x12, 0x1E, 0x28, 0x42, 0x31, 0x04, 0x62, 0x10, 0xC4,
  0x21, 0x88, 0x43, 0x10, 0x8A, 0x1E, 0xE2, 0x00, 0x04, 0x00, 0x06, 0x04,
  0x03, 0xF0, 0x00, 0x04, 0x00, 0x80, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04,
  0x41, 0x04, 0x3F, 0x84, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00, 0x40, 0xFC,
  0x41, 0xA0, 0x50, 0x28, 0x14, 0x0B, 0xF9, 0x04, 0x81, 0x40, 0x60, 0x30,
  0x18, 0x17, 0xF0, 0x0F, 0xCC, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xF0, 0xFC, 0x20, 0xC8,
  0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x81, 0x3F, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x0F, 0xC2, 0x04, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x3F,
  0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0xC0,
  0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x88, 0x44, 0x21, 0x10, 0x48,
  0x14, 0x0C, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x1F, 0xC0, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0xA0, 0x5A, 0x05,
  0xA0, 0x99, 0x09, 0x90, 0x98, 0x91, 0x89, 0x18, 0xA1, 0x86, 0x18, 0x41,
  0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x23, 0x11, 0x84, 0xC1, 0x60,
  0xB0, 0x38, 0x0C, 0x04, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x20, 0x61,
  0xF8, 0xF8, 0x86, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x20, 0x61, 0xE8,
  0x01, 0x00, 0x08, 0x00, 0x40, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x3E, 0x41, 0x80, 0x80, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x01, 0x01, 0x01, 0x01, 0xFE, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x8F, 0xC0, 0x80, 0x30, 0x05,
  0x01, 0x20, 0x24, 0x08, 0x41, 0x08, 0x21, 0x08, 0x11, 0x02, 0x20, 0x28,
  0x05, 0x00, 0xC0, 0x08, 0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x14,
  0x28, 0x28, 0x48, 0x90, 0x91, 0x22, 0x22, 0x24, 0x24, 0x48, 0x50, 0x90,
  0xA0, 0xC1, 0x41, 0x81, 0x03, 0x02, 0x04, 0x00, 0x80, 0x50, 0x22, 0x10,
  0x84, 0x12, 0x05, 0x00, 0xC0, 0x30, 0x14, 0x04, 0x82, 0x11, 0x04, 0x40,
  0xA0, 0x10, 0x80, 0x60, 0x24, 0x09, 0x04, 0x21, 0x04, 0x81, 0x20, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x07, 0xFC,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x09, 0x05, 0x01,
  0x80, 0x80, 0xFE, 0x91, 0x80, 0x7C, 0x04, 0x08, 0x13, 0xE8, 0x60, 0xC1,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x7C, 0x01, 0x01, 0x01, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x3F, 0x3E, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40,
  0x3F, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x00, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01,
  0x01, 0x01, 0xC2, 0x3C, 0x81, 0x02, 0x04, 0x0F, 0xD0, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x8F, 0xFC, 0x20, 0x02, 0x49, 0x24, 0x92,
  0x49, 0x27, 0x00, 0x81, 0x02, 0x04, 0x08, 0x51, 0x24, 0x50, 0xE1, 0x22,
  0x44, 0x48, 0x50, 0x40, 0xFF, 0xFC, 0xFD, 0xF4, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x40, 0xFD,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x1F, 0x00, 0xFC, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x01,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7F, 0x02, 0x04, 0x07, 0x01,
  0x80, 0x81, 0x03, 0xF8, 0x21, 0x04, 0x3E, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x08, 0x3C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x81,
  0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x14, 0x18, 0x08, 0x82, 0x0A, 0x10,
  0x51, 0x44, 0x8A, 0x24, 0x49, 0x14, 0x50, 0xA2, 0x85, 0x0C, 0x10, 0x40,
  0x82, 0x00, 0x41, 0x11, 0x08, 0x82, 0x80, 0x80, 0xA0, 0x50, 0x44, 0x41,
  0x60, 0xC0, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x08,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0xFE, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20,
  0x81, 0xFC, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0xC0, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x0C, 0xFF, 0xFF, 0xF0, 0x83, 0x08, 0x42, 0x10, 0x84, 0x19,
  0x08, 0x42, 0x10, 0x84, 0xC0, 0x70, 0x47, 0xC0,
};

const GFXglyph NotoSans_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 11, 14, 12, 1, -14 },
  { 26, 8, 15, 11, 1, -14 },
  { 41, 13, 14, 15, 1, -14 },
  { 64, 12, 14, 13, 1, -14 },
  { 85, 1, 5, 3, 1, -14 },
  { 86, 3, 17, 5, 1, -14 },
  { 93, 3, 17, 5, 1, -14 },
  { 100, 8, 7, 10, 1, -14 },
  { 107, 9, 9, 11, 1, -11 },
  { 118, 1, 4, 3, 1, -2 },
  { 119, 4, 1, 6, 1, -6 },
  { 120, 1, 1, 4, 2, -1 },
  { 121, 6, 14, 6, 0, -14 },
  { 132, 9, 14, 11, 1, -14 },
  { 148, 4, 14, 11, 2, -14 },
  { 155, 8, 14, 11, 1, -14 },
  { 169, 8, 14, 11, 1, -14 },
  { 183, 11, 14, 11, 0, -14 },
  { 203, 9, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 9, 14, 11, 1, -14 },
  { 251, 9, 14, 11, 1, -14 },
  { 267, 9, 14, 11, 1, -14 },
  { 283, 1, 10, 4, 2, -10 },
  { 285, 2, 12, 4, 1, -10 },
  { 288, 9, 8, 11, 1, -11 },
  { 297, 9, 4, 11, 1, -9 },
  { 302, 9, 8, 11, 1, -11 },
  { 311, 6, 14, 8, 1, -14 },
  { 322, 15, 15, 17, 1, -13 },
  { 351, 11, 14, 11, 0, -14 },
  { 371, 9, 14, 12, 2, -14 },
  { 387, 10, 14, 12, 1, -14 },
  { 405, 10, 14, 13, 2, -14 },
  { 423, 7, 14, 10, 2, -14 },
  { 436, 7, 14, 9, 2, -14 },
  { 449, 11, 14, 14, 1, -14 },
  { 469, 9, 14, 13, 2, -14 },
  { 485, 3, 14, 5, 1, -14 },
  { 491, 5, 17, 4, -2, -14 },
  { 502, 9, 14, 11, 2, -14 },
  { 518, 7, 14, 10, 2, -14 },
  { 531, 12, 14, 16, 2, -14 },
  { 552, 9, 14, 13, 2, -14 },
  { 568, 12, 14, 14, 1, -14 },
  { 589, 8, 14, 11, 2, -14 },
  { 603, 12, 17, 14, 1, -14 },
  { 629, 8, 14, 11, 2, -14 },
  { 643, 8, 14, 10, 1, -14 },
  { 657, 10, 14, 10, 0, -14 },
  { 675, 10, 14, 14, 2, -14 },
  { 693, 11, 14, 11, 0, -14 },
  { 713, 15, 14, 17, 1, -14 },
  { 740, 10, 14, 10, 0, -14 },
  { 758, 10, 14, 10, 0, -14 },
  { 776, 9, 14, 11, 1, -14 },
  { 792, 3, 17, 6, 2, -14 },
  { 799, 6, 14, 6, 0, -14 },
  { 810, 4, 17, 6, 0, -14 },
  { 819, 9, 9, 11, 1, -14 },
  { 830, 7, 1, 7, 0, 1 },
  { 831, 3, 3, 5, 1, -15 },
  { 833, 7, 10, 10, 1, -10 },
  { 842, 8, 14, 11, 2, -14 },
  { 856, 7, 10, 9, 1, -10 },
  { 865, 8, 14, 11, 1, -14 },
  { 879, 8, 10, 10, 1, -10 },
  { 889, 6, 15, 5, 0, -15 },
  { 901, 8, 15, 11, 1, -10 },
  { 916, 7, 14, 11, 2, -14 },
  { 929, 1, 14, 4, 1, -14 },
  { 931, 3, 19, 4, -1, -14 },
  { 939, 7, 14, 9, 2, -14 },
  { 952, 1, 14, 4, 1, -14 },
  { 954, 13, 10, 16, 2, -10 },
  { 971, 7, 10, 11, 2, -10 },
  { 980, 9, 10, 11, 1, -10 },
  { 992, 8, 14, 11, 2, -10 },
  { 1006, 8, 14, 11, 1, -10 },
  { 1020, 5, 10, 7, 2, -10 },
  { 1027, 7, 10, 9, 1, -10 },
  { 1036, 6, 13, 6, 0, -13 },
  { 1046, 7, 10, 11, 2, -10 },
  { 1055, 8, 10, 8, 0, -10 },
  { 1065, 13, 10, 13, 0, -10 },
  { 1082, 9, 10, 9, 0, -10 },
  { 1094, 8, 15, 8, 0, -10 },
  { 1109, 7, 10, 9, 1, -10 },
  { 1118, 6, 17, 6, 0, -14 },
  { 1131, 1, 20, 10, 5, -15 },
  { 1134, 5, 17, 6, 1, -14 },
  { 1145, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Thin19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin19pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_THIN19PT7B_H_
