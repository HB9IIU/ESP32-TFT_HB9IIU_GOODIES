#ifndef _NOTOSANS_THIN52PT7B_H_
#define _NOTOSANS_THIN52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0,
  0x00, 0x01, 0xF6, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x01, 0x00, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x80, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x60, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0x80, 0xC2, 0x0F, 0x18, 0x10, 0x08, 0x80, 0x80,
  0x0C, 0x04, 0x00, 0x40, 0x20, 0x06, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80,
  0x40, 0x0C, 0x02, 0x00, 0x20, 0x10, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x38, 0x20, 0x00, 0x61, 0x00, 0x01, 0xC8, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x17, 0x80, 0x00, 0x87, 0x00, 0x04, 0x1C, 0x00, 0x20, 0x30,
  0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x18, 0x01, 0x00, 0xC0,
  0x08, 0x0D, 0x00, 0x40, 0xCF, 0x02, 0x1C, 0x1F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x10, 0x0C,
  0x00, 0x10, 0x06, 0x00, 0x80, 0x06, 0x00, 0x80, 0x10, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x04, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x60, 0x03, 0x00, 0x10, 0x08, 0x00, 0x40, 0x02, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x40, 0x01, 0x00, 0x08, 0x18, 0x00, 0x30, 0x01,
  0x02, 0x00, 0x06, 0x00, 0x20, 0xC1, 0xE0, 0xC0, 0x04, 0x10, 0xFF, 0x08,
  0x01, 0x84, 0x30, 0x31, 0x00, 0x21, 0x84, 0x03, 0x30, 0x04, 0x21, 0x80,
  0x22, 0x01, 0x8C, 0x20, 0x04, 0x60, 0x61, 0x0C, 0x00, 0xC7, 0xF8, 0x61,
  0x80, 0x18, 0x18, 0x08, 0x30, 0x01, 0x00, 0x03, 0x04, 0x00, 0x20, 0x00,
  0x40, 0x80, 0x04, 0x00, 0x10, 0x10, 0x00, 0x80, 0x06, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x40, 0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x04, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x40, 0x00, 0x80, 0x40, 0x18,
  0x00, 0x18, 0x18, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x10, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x30, 0x01, 0x80, 0x04, 0x20, 0x00, 0xC0, 0x04,
  0x60, 0x00, 0x60, 0x0C, 0x40, 0x00, 0x30, 0x08, 0xC0, 0x00, 0x18, 0x18,
  0xC0, 0x00, 0x0C, 0x10, 0xC0, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x03, 0x20,
  0xC0, 0x00, 0x01, 0x40, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x20, 0x30, 0x00, 0x06, 0x10, 0x18, 0x00, 0x18, 0x08,
  0x0E, 0x00, 0x70, 0x0C, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x38, 0x04, 0x07, 0x3C, 0x10, 0x78, 0x1E, 0x4E, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x68, 0x00, 0x01, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x60, 0x80, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x11, 0x88, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03,
  0x80, 0x60, 0x01, 0x80, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02,
  0x10, 0x00, 0x06, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x88, 0x00, 0x01, 0x18, 0x00, 0x06,
  0x10, 0x00, 0x08, 0x30, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x20, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x0F,
  0x01, 0xB0, 0x73, 0x0C, 0x31, 0x83, 0x70, 0x3C, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0F, 0xFE, 0x00, 0x70,
  0x07, 0x01, 0x80, 0x03, 0x06, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xC0, 0x1E, 0x00, 0x60, 0x38, 0x00, 0x10, 0x60, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x30, 0x78, 0x00, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1B, 0xFF, 0x80, 0x7C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x88,
  0x00, 0x0E, 0x3C, 0x00, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x3F, 0x00, 0x83, 0xFF, 0xC1,
  0x1C, 0x00, 0xC2, 0x60, 0x00, 0xC5, 0x80, 0x00, 0xCE, 0x00, 0x00, 0x98,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x90, 0x00, 0x01, 0x30, 0x00, 0x06, 0x20, 0x00, 0x08, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x40, 0x60, 0x03, 0x00, 0x70, 0x0C, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x18, 0x03, 0x80, 0x40, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x08, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x80, 0x00, 0x31, 0x00, 0x00, 0x43, 0x00, 0x01, 0x83, 0x00, 0x02, 0x03,
  0x00, 0x08, 0x03, 0x00, 0x60, 0x03, 0x83, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0xC0, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06, 0x20, 0x00, 0x04, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x29, 0x00, 0x00, 0x91, 0x00, 0x06,
  0x21, 0x80, 0x18, 0xC1, 0xFF, 0xC1, 0x80, 0x3C, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x04, 0x00, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xB0, 0x19, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0x31, 0x8C, 0x42, 0x31, 0x88,
  0x46, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xFC,
  0x38, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x7F, 0xE0, 0x06, 0x60, 0x01, 0xC0, 0x30, 0x02, 0x60, 0x03,
  0x00, 0x10, 0x02, 0x40, 0x06, 0x00, 0x10, 0x03, 0xC0, 0x0C, 0x00, 0x10,
  0x03, 0xC0, 0x08, 0x00, 0x10, 0x03, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x10, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00,
  0x30, 0x03, 0x80, 0x30, 0x00, 0x30, 0x03, 0x80, 0x30, 0x00, 0x30, 0x03,
  0x80, 0x30, 0x00, 0x30, 0x03, 0x80, 0x10, 0x00, 0x30, 0x02, 0x80, 0x10,
  0x00, 0x70, 0x02, 0x80, 0x18, 0x00, 0x70, 0x06, 0xC0, 0x18, 0x00, 0xD0,
  0x04, 0xC0, 0x0C, 0x01, 0x90, 0x0C, 0x40, 0x06, 0x03, 0x08, 0x18, 0x40,
  0x03, 0xFC, 0x07, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x02, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xE0,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0x00,
  0xC0, 0x01, 0xE0, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x30, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x40, 0x70, 0x00, 0x01, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x40, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x0C, 0xC3, 0x8F, 0xE0, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCC,
  0xC0, 0x00, 0xD8, 0x60, 0x00, 0xF0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xBE, 0x00, 0x00, 0x00,
  0x5D, 0x00, 0x00, 0x00, 0x6E, 0xC0, 0x00, 0x00, 0x27, 0x20, 0x00, 0x00,
  0x33, 0x98, 0x00, 0x00, 0x11, 0xC4, 0x00, 0x00, 0x18, 0xE2, 0x00, 0x00,
  0x0C, 0x71, 0x80, 0x00, 0x04, 0x38, 0x40, 0x00, 0x06, 0x1C, 0x30, 0x00,
  0x02, 0x0E, 0x08, 0x00, 0x03, 0x07, 0x06, 0x00, 0x01, 0x03, 0x83, 0x00,
  0x00, 0x81, 0xC0, 0x80, 0x00, 0xC0, 0xE0, 0x60, 0x00, 0x40, 0x70, 0x10,
  0x00, 0x60, 0x38, 0x0C, 0x00, 0x20, 0x1C, 0x06, 0x00, 0x10, 0x0E, 0x01,
  0x00, 0x18, 0x07, 0x00, 0xC0, 0x08, 0x03, 0x80, 0x20, 0x0C, 0x01, 0xC0,
  0x18, 0x04, 0x00, 0xE0, 0x04, 0x02, 0x00, 0x70, 0x02, 0x03, 0x00, 0x38,
  0x01, 0x81, 0x00, 0x1C, 0x00, 0x41, 0x80, 0x0E, 0x00, 0x30, 0x80, 0x07,
  0x00, 0x08, 0xC0, 0x03, 0x80, 0x04, 0x60, 0x01, 0xC0, 0x03, 0x20, 0x00,
  0xE0, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x02, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x1C, 0x02, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00,
  0x70, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x02,
  0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x02, 0x01, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x02, 0x07, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x30, 0x03, 0xE0, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x07,
  0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0xE0, 0xC0, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xC0, 0xE0, 0x03, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x20, 0x00,
  0x18, 0xE0, 0x01, 0xC0, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03, 0xC0, 0x1E,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x2C, 0x00, 0x01,
  0x40, 0x00, 0x19, 0x00, 0x00, 0x50, 0x00, 0x06, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x30,
  0x80, 0x00, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02, 0x0C, 0x00,
  0x18, 0xC0, 0x01, 0x81, 0x00, 0x04, 0x10, 0x00, 0x60, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x18, 0x00, 0xC1, 0x80, 0x04, 0x06, 0x00, 0x20, 0x20, 0x03,
  0x00, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x20, 0x02, 0x03, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x40, 0x06, 0x03, 0x00, 0x20,
  0x30, 0x00, 0x80, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0x80, 0x03, 0x04, 0x00, 0x10, 0x60, 0x00, 0x41,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x00, 0x88, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x09, 0x80, 0x00, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x16, 0x00, 0x00,
  0x50, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x80,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x10, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x30, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00, 0x10, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x02, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x01, 0x00,
  0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x02, 0x60, 0x00, 0x03, 0x10, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0,
  0x30, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x30,
  0x00, 0xC0, 0x10, 0x00, 0x20, 0x18, 0x00, 0x18, 0x08, 0x00, 0x04, 0x0C,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x66, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xFE, 0x00, 0x7E, 0x78, 0x1C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x70, 0x0F, 0xFF, 0x07, 0x80, 0x11, 0xC0, 0x01, 0x30, 0x00,
  0x16, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x05, 0x60, 0x00, 0xD3, 0x00, 0x19, 0x18,
  0x07, 0x10, 0xFF, 0xC1, 0x00, 0x80, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x81, 0xFE, 0x02, 0x1E, 0x0E, 0x08, 0xC0, 0x0C,
  0x26, 0x00, 0x18, 0xB0, 0x00, 0x33, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xB0,
  0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB8, 0x00, 0x0C, 0xB0, 0x00,
  0x22, 0x60, 0x03, 0x08, 0xC0, 0x18, 0x21, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0x0F, 0x07, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x0F, 0xF0, 0x60, 0x78, 0x78, 0xC1, 0x80, 0x19, 0x8C, 0x00, 0x1B, 0x10,
  0x00, 0x16, 0x60, 0x00, 0x1C, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x74, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x80, 0x00, 0x1D, 0x80, 0x00, 0x39, 0x80, 0x00, 0xF1, 0x00, 0x01, 0x63,
  0x00, 0x04, 0xC3, 0x80, 0x30, 0x81, 0xFF, 0xC1, 0x00, 0x38, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0x1E, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x08, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x02, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x20, 0x70,
  0x03, 0x80, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x07, 0xFF,
  0x80, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xC7, 0x8C, 0x38, 0x01, 0x98, 0xC0, 0x01, 0xB1, 0x00, 0x01, 0xE6, 0x00,
  0x01, 0xC8, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0x98, 0x00, 0x0F, 0x10, 0x00, 0x36, 0x38, 0x00, 0xCC, 0x18,
  0x03, 0x18, 0x1F, 0xFC, 0x30, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x84, 0x00, 0x06, 0x0F, 0x00, 0x38,
  0x07, 0xFF, 0xC0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x81, 0xFE, 0x08,
  0x78, 0x78, 0x8C, 0x00, 0xC9, 0x00, 0x06, 0xA0, 0x00, 0x2E, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFD, 0x00, 0x00, 0x01, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x01, 0xC0, 0x70,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0xFE, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x05, 0x00, 0x03, 0x20, 0x00, 0xC4, 0x00,
  0x30, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x06,
  0x01, 0x01, 0x80, 0x20, 0x60, 0x04, 0x18, 0x00, 0x86, 0x00, 0x11, 0xE0,
  0x02, 0x26, 0x00, 0x48, 0x60, 0x0A, 0x04, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x04, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x01, 0x82, 0x00, 0x18, 0x40, 0x01,
  0x88, 0x00, 0x11, 0x00, 0x03, 0x20, 0x00, 0x34, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xFC, 0x11, 0xE3, 0xC0, 0xF1, 0xE2,
  0x60, 0x0C, 0x30, 0x06, 0x58, 0x00, 0xCC, 0x00, 0x6A, 0x00, 0x0B, 0x00,
  0x05, 0x80, 0x01, 0x40, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x01, 0xFC, 0x08, 0x78, 0x78, 0x8C,
  0x00, 0xC9, 0x00, 0x06, 0xA0, 0x00, 0x2E, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x7F, 0x00, 0x03, 0xC7, 0xC0, 0x06, 0x00,
  0x70, 0x08, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x02, 0x1F, 0x1E,
  0x08, 0xC0, 0x0E, 0x26, 0x00, 0x08, 0xB0, 0x00, 0x12, 0x80, 0x00, 0x6E,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2E, 0x00, 0x01, 0xA8, 0x00,
  0x04, 0xB0, 0x00, 0x22, 0x60, 0x01, 0x88, 0xE0, 0x1C, 0x20, 0xFF, 0xC0,
  0x80, 0x30, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0x87, 0x0C, 0x38, 0x01, 0x98, 0xC0, 0x01, 0xB1, 0x00, 0x01, 0x64,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xA0, 0x00, 0x07, 0x40, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0xE8, 0x00, 0x01,
  0xD8, 0x00, 0x03, 0x90, 0x00, 0x0B, 0x30, 0x00, 0x36, 0x30, 0x00, 0xCC,
  0x38, 0x07, 0x18, 0x1F, 0xF8, 0x30, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x01, 0xFA, 0x3E, 0x79, 0x80, 0x2C, 0x00, 0xA0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x01, 0xF1, 0xFC, 0x60, 0x01,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x1B, 0xC0, 0x0E, 0x1F, 0xFF, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x3F, 0xFF, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0F, 0xF0, 0x02, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0,
  0x00, 0x1D, 0x80, 0x00, 0xA4, 0x00, 0x09, 0x30, 0x00, 0xC8, 0xE0, 0x18,
  0x41, 0xFF, 0x82, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x41, 0x00,
  0x03, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0, 0x04,
  0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x40, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x20, 0x00, 0x21,
  0x80, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x24, 0x00, 0x0E, 0x00, 0x09, 0x00, 0x06,
  0x80, 0x06, 0x60, 0x01, 0x20, 0x01, 0x08, 0x00, 0x4C, 0x00, 0x42, 0x00,
  0x31, 0x00, 0x10, 0xC0, 0x08, 0x40, 0x0C, 0x30, 0x02, 0x18, 0x02, 0x04,
  0x01, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x60, 0x10, 0x30, 0x18,
  0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0xC0, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00,
  0xC2, 0x00, 0x63, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x01, 0x90, 0x00, 0xD8, 0x00, 0x24, 0x00, 0x34, 0x00, 0x0B, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x41, 0x80, 0x03,
  0x02, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x18, 0x02, 0x00, 0x20, 0x18, 0x00,
  0x40, 0xC0, 0x01, 0x82, 0x00, 0x03, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x1A,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x80, 0x60, 0x06,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0x80, 0x06, 0x04, 0x00, 0x0C, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x05, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x41,
  0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0,
  0x04, 0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x40, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x20, 0x00,
  0x21, 0x80, 0x00, 0x84, 0x00, 0x03, 0x10, 0x00, 0x04, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x0F, 0x9C, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 37, 12, 4, -37 },
  { 15, 9, 13, 17, 4, -37 },
  { 30, 31, 37, 34, 1, -37 },
  { 174, 21, 42, 30, 3, -39 },
  { 285, 35, 39, 41, 3, -38 },
  { 456, 32, 39, 37, 3, -38 },
  { 612, 1, 13, 9, 4, -37 },
  { 614, 9, 45, 13, 2, -37 },
  { 665, 9, 45, 13, 2, -37 },
  { 716, 22, 20, 29, 3, -39 },
  { 771, 24, 24, 30, 3, -30 },
  { 843, 5, 13, 10, 2, -6 },
  { 852, 13, 2, 17, 2, -15 },
  { 856, 3, 3, 11, 4, -3 },
  { 858, 15, 37, 17, 1, -37 },
  { 928, 23, 39, 30, 3, -38 },
  { 1041, 12, 37, 30, 5, -37 },
  { 1097, 23, 38, 30, 3, -38 },
  { 1207, 24, 39, 30, 2, -38 },
  { 1324, 28, 37, 30, 1, -37 },
  { 1454, 22, 38, 30, 4, -37 },
  { 1559, 23, 39, 30, 4, -38 },
  { 1672, 24, 37, 30, 3, -37 },
  { 1783, 23, 39, 30, 3, -38 },
  { 1896, 23, 39, 30, 3, -38 },
  { 2009, 3, 28, 11, 4, -28 },
  { 2020, 5, 35, 11, 2, -28 },
  { 2042, 24, 23, 30, 3, -30 },
  { 2111, 24, 12, 30, 3, -24 },
  { 2147, 24, 23, 30, 3, -30 },
  { 2216, 17, 38, 21, 2, -38 },
  { 2297, 40, 42, 46, 3, -37 },
  { 2507, 30, 37, 30, 0, -37 },
  { 2646, 24, 37, 32, 5, -37 },
  { 2757, 27, 39, 32, 3, -38 },
  { 2889, 28, 37, 36, 5, -37 },
  { 3019, 20, 37, 29, 5, -37 },
  { 3112, 20, 37, 26, 5, -37 },
  { 3205, 30, 39, 37, 3, -38 },
  { 3352, 26, 37, 37, 5, -37 },
  { 3473, 9, 37, 15, 3, -37 },
  { 3515, 12, 46, 12, -5, -37 },
  { 3584, 24, 37, 29, 5, -37 },
  { 3695, 20, 37, 26, 5, -37 },
  { 3788, 33, 37, 44, 5, -37 },
  { 3941, 26, 37, 36, 5, -37 },
  { 4062, 33, 39, 39, 3, -38 },
  { 4223, 22, 37, 30, 5, -37 },
  { 4325, 33, 47, 39, 3, -38 },
  { 4519, 24, 37, 30, 5, -37 },
  { 4630, 22, 39, 28, 3, -38 },
  { 4738, 26, 37, 26, 0, -37 },
  { 4859, 27, 38, 37, 5, -37 },
  { 4988, 29, 37, 29, 0, -37 },
  { 5123, 42, 37, 45, 2, -37 },
  { 5318, 27, 37, 26, 0, -37 },
  { 5443, 26, 37, 26, 0, -37 },
  { 5564, 26, 37, 30, 2, -37 },
  { 5685, 10, 45, 16, 5, -37 },
  { 5742, 15, 37, 17, 1, -37 },
  { 5812, 11, 45, 16, 1, -37 },
  { 5874, 25, 23, 30, 2, -37 },
  { 5946, 20, 1, 20, 0, 5 },
  { 5949, 9, 8, 13, 2, -40 },
  { 5958, 20, 29, 27, 2, -28 },
  { 6031, 22, 41, 30, 5, -40 },
  { 6144, 20, 29, 25, 3, -28 },
  { 6217, 23, 41, 30, 3, -40 },
  { 6335, 22, 29, 28, 3, -28 },
  { 6415, 17, 40, 14, 1, -40 },
  { 6500, 23, 40, 30, 3, -28 },
  { 6615, 20, 40, 30, 5, -40 },
  { 6715, 3, 37, 11, 4, -37 },
  { 6729, 10, 49, 11, -3, -37 },
  { 6791, 19, 40, 24, 5, -40 },
  { 6886, 1, 40, 11, 5, -40 },
  { 6891, 35, 28, 44, 5, -28 },
  { 7014, 20, 28, 30, 5, -28 },
  { 7084, 24, 29, 30, 3, -28 },
  { 7171, 22, 40, 30, 5, -28 },
  { 7281, 23, 40, 30, 3, -28 },
  { 7396, 14, 28, 20, 5, -28 },
  { 7445, 19, 29, 24, 2, -28 },
  { 7514, 14, 35, 17, 1, -34 },
  { 7576, 21, 28, 30, 4, -27 },
  { 7650, 22, 27, 22, 0, -27 },
  { 7725, 34, 27, 36, 1, -27 },
  { 7840, 22, 27, 25, 1, -27 },
  { 7915, 22, 40, 22, 0, -27 },
  { 8025, 20, 27, 24, 2, -27 },
  { 8093, 15, 45, 18, 1, -37 },
  { 8178, 1, 53, 28, 13, -40 },
  { 8185, 14, 45, 18, 2, -37 },
  { 8264, 24, 5, 30, 3, -21 },
};

const GFXfont NotoSans_Thin52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin52pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_THIN52PT7B_H_
