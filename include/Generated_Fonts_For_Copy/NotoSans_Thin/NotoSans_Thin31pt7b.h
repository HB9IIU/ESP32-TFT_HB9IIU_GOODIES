#ifndef _NOTOSANS_THIN31PT7B_H_
#define _NOTOSANS_THIN31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x8C, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x41, 0xFF, 0xFF, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x04, 0x0F, 0xFF, 0xF8, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00,
  0x02, 0x00, 0x10, 0x03, 0xE0, 0x64, 0xE4, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x64, 0x00, 0xE0, 0x01, 0xC0, 0x09,
  0x80, 0x42, 0x02, 0x10, 0x10, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x1B,
  0x8B, 0x01, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x82, 0x10, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x40, 0x82, 0x02, 0x04,
  0x20, 0x10, 0x21, 0x00, 0x81, 0x11, 0xC4, 0x08, 0x91, 0x20, 0x49, 0x04,
  0x84, 0x88, 0x22, 0x64, 0x80, 0x8C, 0x44, 0x04, 0x02, 0x20, 0x20, 0x21,
  0x01, 0x01, 0x08, 0x08, 0x10, 0x40, 0x40, 0x82, 0x04, 0x08, 0x08, 0x20,
  0x80, 0x41, 0x04, 0x01, 0xF0, 0x0F, 0xE0, 0x02, 0x02, 0x00, 0x40, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x41, 0x00,
  0x08, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x08, 0x80, 0x06, 0x08, 0x04,
  0x80, 0x80, 0xA0, 0x08, 0x24, 0x00, 0x84, 0x80, 0x09, 0x10, 0x00, 0xA2,
  0x00, 0x08, 0x20, 0x02, 0x86, 0x01, 0x88, 0x3F, 0xC0, 0xC0, 0xFF, 0x0C,
  0x21, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0xC0, 0xC1, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x08, 0x21, 0x08, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x71, 0x1C, 0x7F, 0x00, 0x40, 0x05, 0x00, 0x44, 0x02, 0x20, 0x20,
  0x82, 0x02, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x24, 0xA4, 0xA4, 0xFF, 0xC0, 0x00, 0xC0, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30,
  0x00, 0x1F, 0xC0, 0x80, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x09, 0x00, 0x24, 0x00, 0x88, 0x04,
  0x30, 0x20, 0x3F, 0x00, 0x06, 0x14, 0x4B, 0x18, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x3F, 0xC6, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x7F, 0xFC,
  0x1F, 0xE1, 0x80, 0x44, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFC, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x80,
  0x11, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x50, 0x00, 0x50, 0x00,
  0x90, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F,
  0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x80, 0x21,
  0xFF, 0x00, 0x00, 0xE0, 0x1C, 0x40, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x0C, 0x09, 0xC6, 0x28, 0x04, 0xC0,
  0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x20, 0x08, 0x40, 0x40, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0xE0,
  0x80, 0x44, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x88, 0x04,
  0x10, 0x60, 0x32, 0x00, 0x78, 0x06, 0x18, 0x20, 0x11, 0x00, 0x28, 0x00,
  0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x20, 0x10, 0x7F,
  0x80, 0x1F, 0xC1, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x34, 0x01, 0x50, 0x09, 0x38, 0xC8,
  0x1C, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0xC1, 0xFC, 0x00, 0x80, 0x03, 0x20, 0x00, 0x00, 0x00, 0x02, 0x4A,
  0x4A, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x40, 0x1E, 0x02, 0x40, 0x61, 0x82,
  0x80, 0x80, 0x82, 0x81, 0x00, 0x81, 0x82, 0x01, 0x01, 0x82, 0x01, 0x01,
  0x82, 0x01, 0x01, 0x82, 0x01, 0x02, 0x82, 0x01, 0x02, 0x82, 0x01, 0x02,
  0x81, 0x02, 0x84, 0x81, 0x84, 0x8C, 0x80, 0x38, 0x70, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04, 0x08, 0x01,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x07, 0xFF, 0x81, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0xA0, 0x00, 0x10, 0xFF, 0xE2, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0xCF, 0xFE,
  0x20, 0x04, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x80, 0x33, 0xFF, 0x00, 0x03, 0xFF, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x80, 0x30, 0x80, 0x0C, 0x80, 0x06,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x78, 0x00, 0xE1, 0xE0, 0xC0,
  0x04, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x04, 0x80, 0x01, 0x10, 0x00, 0x43, 0x00, 0x10, 0x3F, 0xF8, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x7C, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0B, 0xE0, 0x80, 0x0E, 0x00, 0x48,
  0x02, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x88, 0x02,
  0x60, 0x0A, 0x40, 0x30, 0x80, 0x82, 0x02, 0x04, 0x08, 0x08, 0x20, 0x10,
  0x80, 0x42, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x10, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xA0, 0x00, 0x5A, 0x00, 0x05, 0xA0, 0x00, 0x59, 0x00, 0x09, 0x90,
  0x00, 0x98, 0x80, 0x11, 0x88, 0x01, 0x18, 0x80, 0x21, 0x84, 0x02, 0x18,
  0x40, 0x21, 0x82, 0x04, 0x18, 0x20, 0x41, 0x81, 0x08, 0x18, 0x10, 0x81,
  0x81, 0x08, 0x18, 0x09, 0x01, 0x80, 0x90, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0D, 0x00, 0x19, 0x00,
  0x31, 0x00, 0x62, 0x00, 0xC2, 0x01, 0x82, 0x03, 0x04, 0x06, 0x04, 0x0C,
  0x04, 0x18, 0x08, 0x30, 0x08, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x13, 0x00,
  0x16, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x40, 0x07, 0xFC, 0x01,
  0x00, 0x60, 0x40, 0x02, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x40,
  0x00, 0x48, 0x00, 0x08, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x30, 0x0F,
  0xF8, 0x00, 0xFF, 0xC4, 0x01, 0x20, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x09, 0x03, 0x8F, 0xA0, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x07, 0xFC, 0x01, 0x00, 0x60, 0x40, 0x02, 0x10, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x08, 0x80, 0x02, 0x08,
  0x00, 0x40, 0x80, 0x30, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xFF, 0xC2, 0x00, 0x88, 0x01,
  0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x48, 0x06, 0x3F, 0xE0, 0x81, 0x02, 0x02, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x22, 0x00, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x10, 0x1F, 0xFB,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x7F, 0xE0, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x60, 0x02, 0x30, 0x0C,
  0x0F, 0xF0, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x10, 0x80, 0x08, 0x20, 0x04, 0x10, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x40, 0x04, 0x20,
  0x02, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x50, 0x05, 0x00, 0x48, 0x02,
  0x80, 0x24, 0x01, 0x40, 0x12, 0x01, 0x20, 0x08, 0x80, 0x88, 0x08, 0x40,
  0x44, 0x04, 0x20, 0x22, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x81, 0x08, 0x10, 0x40, 0x44, 0x04, 0x40, 0x22, 0x02, 0x20,
  0x11, 0x01, 0x10, 0x09, 0x00, 0x50, 0x02, 0x80, 0x28, 0x01, 0x40, 0x14,
  0x00, 0xA0, 0x0A, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x20, 0x04,
  0x20, 0x04, 0x40, 0x02, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x7F, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x08, 0x40, 0x10, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x20, 0xFF, 0xF0, 0x82,
  0x08, 0x20, 0x80, 0x07, 0x03, 0x86, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x0F, 0xF3, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x34, 0x05, 0x3F, 0x90, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x11, 0xF0, 0x90, 0x65, 0x00, 0xB0, 0x05, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x60, 0x0A, 0x80, 0x93, 0xF8, 0x03, 0xC1, 0xC3, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0xF1, 0x18,
  0x69, 0x00, 0xD0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x0C, 0x80, 0xA3,
  0xF9, 0x03, 0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00,
  0x30, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x01, 0x1F, 0xF0, 0x03, 0xE0, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0xFF, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x07, 0x80, 0xC3, 0x48, 0x06, 0x80, 0x14, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0,
  0x05, 0x00, 0x64, 0x05, 0x1F, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0A, 0x00, 0x4F, 0xFC, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0xF8, 0xB0, 0x4C, 0x02, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x50, 0x0C,
  0x10, 0x00, 0x00, 0x00, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0xF8, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x50, 0x12, 0x04,
  0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x40, 0xA4, 0x18, 0x82, 0x08, 0x40,
  0x88, 0x09, 0x01, 0x20, 0x14, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xC5,
  0x84, 0x61, 0x30, 0x14, 0x05, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x07, 0x89, 0x84, 0xA0, 0x2C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x61, 0x82,
  0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x09, 0x00, 0x24, 0x01, 0x88, 0x0C,
  0x1F, 0xC0, 0x07, 0x84, 0xC3, 0x28, 0x05, 0x80, 0x28, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0B, 0x00, 0x54, 0x04, 0x9F, 0xC4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x03, 0x80, 0xC3, 0x48, 0x06, 0x80, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x05, 0x00, 0x64, 0x05, 0x1F, 0xC8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x0F, 0xB0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x0F, 0x03, 0x06, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x28,
  0x02, 0x7F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0xF0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x40,
  0x53, 0xF9, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10,
  0x40, 0x82, 0x08, 0x10, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02,
  0x80, 0x0C, 0x00, 0x40, 0xC0, 0x20, 0x0A, 0x01, 0x80, 0x90, 0x0C, 0x04,
  0x40, 0x90, 0x22, 0x04, 0x81, 0x10, 0x24, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x84, 0x10, 0x84, 0x40, 0x88, 0x22, 0x02, 0x40, 0x90, 0x12, 0x04, 0x80,
  0xA0, 0x28, 0x05, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0xC0, 0x1A,
  0x01, 0x08, 0x18, 0x20, 0x80, 0x88, 0x04, 0x80, 0x14, 0x00, 0x40, 0x05,
  0x00, 0x48, 0x02, 0x20, 0x20, 0x82, 0x04, 0x10, 0x11, 0x00, 0x50, 0x01,
  0x80, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x02,
  0xC0, 0x08, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x0F, 0xFF, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x08, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x60, 0x0C, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x30, 0x00, 0x7E, 0x06, 0x07, 0xE0,
};

const GFXglyph NotoSans_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 22, 7, 3, -22 },
  { 4, 6, 8, 10, 2, -22 },
  { 10, 18, 22, 20, 1, -22 },
  { 60, 13, 26, 18, 2, -24 },
  { 103, 21, 22, 25, 2, -22 },
  { 161, 19, 22, 22, 2, -22 },
  { 214, 1, 8, 5, 2, -22 },
  { 215, 6, 27, 8, 1, -22 },
  { 236, 6, 27, 8, 1, -22 },
  { 257, 13, 13, 17, 2, -24 },
  { 279, 14, 14, 18, 2, -18 },
  { 304, 3, 8, 6, 1, -4 },
  { 307, 8, 1, 10, 1, -9 },
  { 308, 1, 2, 7, 3, -2 },
  { 309, 10, 22, 10, 0, -22 },
  { 337, 14, 22, 18, 2, -22 },
  { 376, 7, 22, 18, 3, -22 },
  { 396, 13, 22, 18, 2, -22 },
  { 432, 14, 22, 18, 1, -22 },
  { 471, 16, 22, 18, 1, -22 },
  { 515, 14, 22, 18, 2, -22 },
  { 554, 14, 23, 18, 2, -23 },
  { 595, 14, 22, 18, 2, -22 },
  { 634, 14, 22, 18, 2, -22 },
  { 673, 14, 22, 18, 2, -22 },
  { 712, 1, 16, 7, 3, -16 },
  { 714, 3, 20, 7, 1, -16 },
  { 722, 14, 14, 18, 2, -18 },
  { 747, 14, 7, 18, 2, -14 },
  { 760, 14, 14, 18, 2, -18 },
  { 785, 11, 22, 13, 1, -22 },
  { 816, 24, 25, 27, 2, -22 },
  { 891, 18, 22, 18, 0, -22 },
  { 941, 14, 22, 19, 3, -22 },
  { 980, 16, 22, 19, 2, -22 },
  { 1024, 16, 22, 21, 3, -22 },
  { 1068, 12, 22, 17, 3, -22 },
  { 1101, 12, 22, 15, 3, -22 },
  { 1134, 18, 23, 22, 2, -23 },
  { 1186, 16, 22, 22, 3, -22 },
  { 1230, 5, 22, 9, 2, -22 },
  { 1244, 7, 27, 7, -3, -22 },
  { 1268, 14, 22, 17, 3, -22 },
  { 1307, 12, 22, 16, 3, -22 },
  { 1340, 20, 22, 26, 3, -22 },
  { 1395, 15, 22, 22, 3, -22 },
  { 1437, 19, 22, 23, 2, -22 },
  { 1490, 13, 22, 18, 3, -22 },
  { 1526, 19, 27, 23, 2, -22 },
  { 1591, 14, 22, 18, 3, -22 },
  { 1630, 13, 22, 17, 2, -22 },
  { 1666, 16, 22, 16, 0, -22 },
  { 1710, 16, 22, 22, 3, -22 },
  { 1754, 17, 22, 17, 0, -22 },
  { 1801, 25, 22, 27, 1, -22 },
  { 1870, 16, 22, 16, 0, -22 },
  { 1914, 16, 22, 16, 0, -22 },
  { 1958, 16, 22, 18, 1, -22 },
  { 2002, 6, 27, 10, 3, -22 },
  { 2023, 10, 22, 10, 0, -22 },
  { 2051, 6, 27, 10, 1, -22 },
  { 2072, 15, 13, 18, 1, -22 },
  { 2097, 12, 1, 12, 0, 3 },
  { 2099, 5, 5, 8, 1, -24 },
  { 2103, 12, 17, 16, 1, -17 },
  { 2129, 13, 24, 18, 3, -24 },
  { 2168, 12, 17, 15, 2, -17 },
  { 2194, 13, 24, 18, 2, -24 },
  { 2233, 13, 17, 17, 2, -17 },
  { 2261, 11, 24, 9, 0, -24 },
  { 2294, 13, 24, 18, 2, -17 },
  { 2333, 12, 24, 18, 3, -24 },
  { 2369, 2, 22, 6, 2, -22 },
  { 2375, 6, 29, 6, -2, -22 },
  { 2397, 11, 24, 14, 3, -24 },
  { 2430, 1, 24, 6, 3, -24 },
  { 2433, 21, 17, 26, 3, -17 },
  { 2478, 12, 17, 18, 3, -17 },
  { 2504, 14, 17, 18, 2, -17 },
  { 2534, 13, 24, 18, 3, -17 },
  { 2573, 13, 24, 18, 2, -17 },
  { 2612, 8, 17, 12, 3, -17 },
  { 2629, 12, 17, 14, 1, -17 },
  { 2655, 9, 20, 10, 0, -20 },
  { 2678, 12, 16, 18, 3, -16 },
  { 2702, 13, 16, 13, 0, -16 },
  { 2728, 21, 16, 21, 0, -16 },
  { 2770, 13, 16, 15, 1, -16 },
  { 2796, 13, 24, 13, 0, -16 },
  { 2835, 12, 16, 14, 1, -16 },
  { 2859, 8, 27, 10, 1, -22 },
  { 2886, 1, 32, 17, 8, -24 },
  { 2890, 9, 27, 10, 1, -22 },
  { 2921, 14, 2, 18, 2, -12 },
};

const GFXfont NotoSans_Thin31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin31pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_THIN31PT7B_H_
