#ifndef _NOTOSANS_THIN40PT7B_H_
#define _NOTOSANS_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x03, 0xC0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80,
  0x40, 0x3F, 0xFF, 0xFF, 0x00, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x02, 0x01, 0x00, 0x02, 0x01,
  0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x0F, 0xF0, 0x31, 0x0E, 0x41, 0x00, 0x81, 0x00, 0x81, 0x00,
  0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x00, 0x61, 0x00,
  0x31, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0x60, 0x01, 0x18, 0x01, 0x04,
  0x01, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03,
  0x01, 0x02, 0x01, 0x06, 0x81, 0x0C, 0xFD, 0x70, 0x03, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x04, 0x06, 0x10, 0x00, 0x80, 0x81, 0x00, 0x20,
  0x20, 0x30, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x08,
  0x08, 0x04, 0x01, 0x02, 0x00, 0x80, 0x20, 0x40, 0x10, 0x04, 0x10, 0x02,
  0x00, 0x82, 0x00, 0x60, 0x10, 0x82, 0x04, 0x02, 0x11, 0xF8, 0x80, 0x44,
  0x41, 0x90, 0x11, 0x98, 0x11, 0x02, 0x22, 0x01, 0x30, 0x88, 0x40, 0x21,
  0xE1, 0x08, 0x04, 0x00, 0x43, 0x00, 0x80, 0x08, 0x60, 0x10, 0x02, 0x08,
  0x02, 0x00, 0x41, 0x80, 0x40, 0x10, 0x30, 0x08, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x08, 0x04, 0x04, 0x01, 0x81, 0x01, 0x00, 0x10,
  0x60, 0x60, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x04,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x20, 0x30, 0x02, 0x40, 0x18, 0x06, 0x80, 0x0C,
  0x04, 0x80, 0x04, 0x04, 0x80, 0x02, 0x08, 0x80, 0x01, 0x08, 0x80, 0x00,
  0x90, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0xC0, 0x00, 0xD0, 0x60, 0x01,
  0x88, 0x30, 0x06, 0x04, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x06, 0x08, 0x20,
  0xC1, 0x04, 0x08, 0x30, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x18, 0xC0, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x02, 0x04, 0x07, 0xE2, 0x1C, 0x0F, 0x70, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x48, 0x00, 0x42, 0x00, 0x61, 0x80, 0x20, 0x40, 0x20, 0x10, 0x30,
  0x08, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x25, 0xA4, 0x94, 0x90,
  0xFF, 0x80, 0xF0, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x00, 0x03, 0xF8, 0x01, 0x83, 0x00,
  0x80, 0x20, 0x40, 0x04, 0x20, 0x01, 0x88, 0x00, 0x22, 0x00, 0x09, 0x00,
  0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x00, 0x84, 0x00, 0x41, 0x80, 0x30, 0x30, 0x18, 0x03, 0xF8,
  0x00, 0x00, 0x81, 0xC1, 0xA1, 0x13, 0x0B, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xF0,
  0x07, 0x07, 0x02, 0x00, 0x61, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0x03, 0x06, 0x00, 0x22, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x33, 0x00, 0x18, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00,
  0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x04, 0x08,
  0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00, 0x40,
  0x80, 0x02, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xFE, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x05, 0xFF, 0x03, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x98, 0x01, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x40, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x03, 0x00, 0x8F, 0xBC, 0x26, 0x01,
  0x8A, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x2C, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x88, 0x00, 0x41, 0x00, 0x30, 0x60, 0x18, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x0C, 0x0E, 0x08, 0x01, 0x88,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x01, 0x08, 0x01, 0x83, 0x01, 0x80, 0xE3, 0x00, 0x1E, 0x00, 0x1D,
  0xC0, 0x30, 0x30, 0x30, 0x06, 0x20, 0x01, 0xB0, 0x00, 0x50, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x98, 0x00, 0x86, 0x00, 0x80, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0x03, 0x01,
  0x00, 0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x2C, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00,
  0xD0, 0x00, 0x36, 0x00, 0x14, 0xC0, 0x09, 0x18, 0x0C, 0x41, 0xFC, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x25, 0xA4, 0x94, 0x90, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0x86, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x02, 0x20, 0x07, 0xFC, 0x04,
  0x80, 0x10, 0x08, 0x0D, 0x00, 0xC0, 0x10, 0x0A, 0x01, 0x00, 0x20, 0x1C,
  0x04, 0x00, 0x40, 0x30, 0x08, 0x00, 0x80, 0x60, 0x30, 0x01, 0x00, 0xC0,
  0x40, 0x02, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x01, 0x00, 0x10, 0x06, 0x03,
  0x00, 0x20, 0x14, 0x02, 0x00, 0x60, 0x28, 0x04, 0x01, 0x40, 0x48, 0x04,
  0x04, 0x81, 0x10, 0x06, 0x30, 0xCC, 0x20, 0x07, 0x80, 0xE0, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11,
  0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x30, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0x30,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0xC0, 0x20, 0x00, 0x80,
  0x40, 0x01, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x20, 0xFF, 0x40, 0x20, 0x3F, 0x08, 0x00, 0x32,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x06, 0x3F, 0xFF,
  0x08, 0x0F, 0xC2, 0x00, 0x0C, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x38, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x1C, 0x07, 0x06, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x01, 0xFF, 0xE0,
  0xFF, 0x00, 0x04, 0x0F, 0xE0, 0x20, 0x01, 0xC1, 0x00, 0x03, 0x08, 0x00,
  0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0xD0, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0xC1, 0x00,
  0x38, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0x80, 0x78, 0x18, 0x00, 0x10, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0x90, 0x00, 0x01, 0x30, 0x00,
  0x02, 0x30, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00, 0x70, 0x0F, 0xFF,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x8F, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xA0, 0x9F, 0x80, 0x80, 0x00, 0xE0,
  0x00, 0x68, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04, 0x20, 0x02, 0x08, 0x01,
  0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08, 0x10, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x22, 0x80, 0x09, 0x30, 0x02, 0x84, 0x00, 0xC0, 0x80, 0x20,
  0x10, 0x08, 0x06, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x06, 0x08, 0x00,
  0xC2, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x1A, 0x00, 0x02,
  0x80, 0x00, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xE0, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x74, 0x00, 0x00, 0x7A, 0x00,
  0x00, 0x2C, 0x80, 0x00, 0x16, 0x40, 0x00, 0x13, 0x10, 0x00, 0x09, 0x88,
  0x00, 0x0C, 0xC6, 0x00, 0x04, 0x61, 0x00, 0x02, 0x30, 0x80, 0x02, 0x18,
  0x20, 0x01, 0x0C, 0x10, 0x01, 0x06, 0x0C, 0x00, 0x83, 0x02, 0x00, 0x41,
  0x81, 0x00, 0x40, 0xC0, 0x40, 0x20, 0x60, 0x20, 0x20, 0x30, 0x18, 0x10,
  0x18, 0x04, 0x18, 0x0C, 0x02, 0x08, 0x06, 0x00, 0x84, 0x03, 0x00, 0x44,
  0x01, 0x80, 0x32, 0x00, 0xC0, 0x0B, 0x00, 0x60, 0x05, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x08, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1A, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00, 0x18, 0xC0,
  0x01, 0x84, 0x00, 0x18, 0x20, 0x01, 0x83, 0x00, 0x18, 0x10, 0x01, 0x80,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x02, 0x01, 0x80, 0x30, 0x18,
  0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x06, 0x18, 0x00, 0x21,
  0x80, 0x01, 0x18, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x05, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x70,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x40, 0xFC, 0x20, 0x03, 0x10, 0x00, 0x48, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x11, 0x00, 0x70, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x08, 0x00, 0x04,
  0x02, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x20, 0x7E,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x1A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x02, 0x20, 0x01, 0x88, 0x01, 0x83, 0xFF, 0xC0, 0x80, 0x60, 0x20, 0x08,
  0x08, 0x03, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x42,
  0x00, 0x18, 0x80, 0x02, 0x20, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x02, 0x80,
  0x00, 0xC0, 0x03, 0xFC, 0x03, 0x00, 0xE3, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x33, 0x00, 0x18, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x58, 0x00, 0x02,
  0x40, 0x00, 0x33, 0x00, 0x01, 0x0C, 0x00, 0x10, 0x38, 0x03, 0x00, 0x7F,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x30, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x01, 0x00, 0x40,
  0x02, 0x01, 0x00, 0x06, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x48, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0xA0, 0x00, 0xC0, 0x00, 0x90, 0x00,
  0x60, 0x00, 0x48, 0x00, 0x28, 0x00, 0x26, 0x00, 0x14, 0x00, 0x21, 0x00,
  0x12, 0x00, 0x10, 0x80, 0x09, 0x80, 0x08, 0x40, 0x04, 0x40, 0x0C, 0x10,
  0x02, 0x20, 0x04, 0x08, 0x02, 0x10, 0x02, 0x04, 0x01, 0x04, 0x01, 0x02,
  0x00, 0x82, 0x01, 0x80, 0x80, 0xC1, 0x00, 0x80, 0x40, 0x40, 0x80, 0x40,
  0x20, 0x20, 0x20, 0x60, 0x10, 0x10, 0x10, 0x20, 0x04, 0x10, 0x08, 0x10,
  0x02, 0x08, 0x06, 0x08, 0x01, 0x04, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x84,
  0x00, 0x22, 0x00, 0x42, 0x00, 0x11, 0x00, 0x11, 0x00, 0x08, 0x80, 0x09,
  0x00, 0x02, 0xC0, 0x04, 0x80, 0x01, 0x40, 0x03, 0x40, 0x00, 0xA0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x32, 0x00, 0x02, 0x20, 0x00, 0x41, 0x00, 0x04,
  0x18, 0x00, 0x80, 0x80, 0x18, 0x04, 0x01, 0x00, 0x60, 0x20, 0x02, 0x06,
  0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x09, 0x80, 0x00, 0xD0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x18, 0x80, 0x01,
  0x0C, 0x00, 0x20, 0x40, 0x06, 0x02, 0x00, 0x40, 0x30, 0x08, 0x01, 0x01,
  0x80, 0x08, 0x10, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x24, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x22, 0x00,
  0x06, 0x20, 0x00, 0x41, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x10, 0x0C,
  0x01, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x11, 0x00, 0x06,
  0x10, 0x00, 0x82, 0x00, 0x30, 0x20, 0x04, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00,
  0x02, 0x40, 0x00, 0x50, 0x00, 0x04, 0xFF, 0xFF, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x1F, 0xF8, 0x60, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x01, 0xFC, 0x3C, 0x09, 0x80,
  0x14, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x2B, 0x01, 0x93, 0xFE, 0x20, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x80, 0x47, 0xBC, 0x24, 0x03, 0x14, 0x00, 0x4C, 0x00, 0x36, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x60,
  0x00, 0xB0, 0x00, 0x94, 0x00, 0xCB, 0x00, 0xC4, 0x7F, 0x80, 0x00, 0x30,
  0x03, 0xFF, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x40, 0x41, 0xEF, 0x10, 0x80, 0x64, 0x40, 0x05, 0x20, 0x01, 0x58,
  0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03,
  0x40, 0x00, 0xD0, 0x00, 0x32, 0x00, 0x14, 0xC0, 0x0D, 0x18, 0x06, 0x41,
  0xFE, 0x10, 0x00, 0x40, 0x03, 0xFC, 0x03, 0x01, 0x82, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x10, 0x3F,
  0xF0, 0x00, 0x60, 0x0F, 0x70, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xFC, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x40, 0x01, 0xEF,
  0x10, 0x80, 0x24, 0x40, 0x05, 0x20, 0x01, 0xD8, 0x00, 0x34, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00,
  0x32, 0x00, 0x14, 0xC0, 0x0D, 0x18, 0x06, 0x41, 0xFE, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x18, 0x00, 0x83, 0xE3, 0xC0, 0x03, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x80, 0x8F, 0xF8, 0xB0, 0x0C, 0xA0, 0x06, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF4, 0x00, 0x55, 0x55,
  0x55, 0x55, 0x55, 0x40, 0x06, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x53, 0x18, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x28, 0x01, 0x20, 0x08,
  0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0xC0, 0x86, 0x02, 0x30, 0x08, 0xC0,
  0x25, 0x80, 0xA2, 0x03, 0x04, 0x08, 0x18, 0x20, 0x30, 0x80, 0x42, 0x00,
  0x88, 0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x00, 0x08, 0x13, 0xFC, 0x1E, 0xE2, 0xC0, 0x46, 0x02, 0x60, 0x05,
  0x00, 0x2C, 0x00, 0xA0, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x80, 0x8F, 0xF8, 0x90, 0x0C, 0xA0, 0x06, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x30, 0x08, 0x08, 0x00, 0x82, 0x00, 0x08, 0xC0,
  0x01, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x80, 0xC0,
  0x60, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x47, 0xBC, 0x26, 0x03, 0x14, 0x00,
  0x4C, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x94, 0x00, 0xC9, 0x00,
  0xC4, 0x7F, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xFF, 0x10, 0x80, 0x64, 0x40, 0x0D, 0x20, 0x01, 0x58, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x52, 0x00, 0x14, 0xC0, 0x09, 0x18, 0x04, 0x41, 0xFE, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x9F, 0xEC, 0x0E, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x7B, 0xE6, 0x00, 0x50, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x80, 0x19,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x30, 0x19, 0x1F, 0xF1, 0x80,
  0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x81,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x2C, 0x00, 0xC0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01,
  0x90, 0x04, 0x80, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x02, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x01, 0x10,
  0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x02, 0x80, 0x18, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x10, 0x01, 0x0C, 0x01, 0x82,
  0x00, 0x80, 0x80, 0x80, 0x60, 0x80, 0x10, 0xC0, 0x04, 0x40, 0x01, 0x40,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10,
  0x40, 0x10, 0x10, 0x10, 0x0C, 0x08, 0x02, 0x08, 0x00, 0x88, 0x00, 0x2C,
  0x00, 0x18, 0x80, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0xC0, 0x04, 0x40,
  0x02, 0x20, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x04, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x20, 0x3C, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x0F, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x1C, 0x03, 0x80, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x0C, 0x38,
  0x0E, 0x00, 0xE7, 0x00, 0x03, 0x00,
};

const GFXglyph NotoSans_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 29, 9, 3, -29 },
  { 9, 7, 11, 13, 3, -29 },
  { 19, 24, 29, 26, 1, -29 },
  { 106, 16, 32, 23, 3, -30 },
  { 170, 27, 29, 32, 2, -29 },
  { 268, 24, 29, 28, 3, -29 },
  { 355, 1, 11, 7, 3, -29 },
  { 357, 7, 35, 10, 2, -29 },
  { 388, 8, 35, 10, 1, -29 },
  { 423, 17, 16, 22, 2, -30 },
  { 457, 19, 18, 23, 2, -23 },
  { 500, 3, 10, 7, 2, -5 },
  { 504, 9, 1, 13, 2, -11 },
  { 506, 2, 2, 9, 3, -2 },
  { 507, 11, 29, 13, 1, -29 },
  { 547, 18, 29, 23, 2, -29 },
  { 613, 9, 29, 23, 4, -29 },
  { 646, 18, 29, 23, 2, -29 },
  { 712, 18, 29, 23, 2, -29 },
  { 778, 21, 29, 23, 1, -29 },
  { 855, 17, 29, 23, 3, -29 },
  { 917, 18, 29, 23, 3, -29 },
  { 983, 18, 29, 23, 2, -29 },
  { 1049, 17, 29, 23, 3, -29 },
  { 1111, 18, 29, 23, 2, -29 },
  { 1177, 2, 21, 9, 3, -21 },
  { 1183, 3, 26, 9, 2, -21 },
  { 1193, 19, 17, 23, 2, -23 },
  { 1234, 19, 9, 23, 2, -19 },
  { 1256, 19, 17, 23, 2, -23 },
  { 1297, 13, 29, 17, 2, -29 },
  { 1345, 31, 32, 35, 2, -28 },
  { 1469, 23, 29, 23, 0, -29 },
  { 1553, 18, 29, 25, 4, -29 },
  { 1619, 20, 29, 25, 3, -29 },
  { 1692, 21, 29, 28, 4, -29 },
  { 1769, 16, 29, 22, 4, -29 },
  { 1827, 16, 29, 20, 4, -29 },
  { 1885, 23, 29, 29, 3, -29 },
  { 1969, 20, 29, 28, 4, -29 },
  { 2042, 7, 29, 11, 2, -29 },
  { 2068, 9, 36, 9, -4, -29 },
  { 2109, 18, 29, 22, 4, -29 },
  { 2175, 15, 29, 20, 4, -29 },
  { 2230, 25, 29, 33, 4, -29 },
  { 2321, 20, 29, 28, 4, -29 },
  { 2394, 25, 29, 30, 3, -29 },
  { 2485, 17, 29, 23, 4, -29 },
  { 2547, 25, 36, 30, 3, -29 },
  { 2660, 18, 29, 23, 4, -29 },
  { 2726, 18, 29, 22, 2, -29 },
  { 2792, 20, 29, 20, 0, -29 },
  { 2865, 21, 29, 28, 4, -29 },
  { 2942, 23, 29, 23, 0, -29 },
  { 3026, 33, 29, 35, 1, -29 },
  { 3146, 20, 29, 20, 0, -29 },
  { 3219, 20, 29, 20, 0, -29 },
  { 3292, 21, 29, 23, 1, -29 },
  { 3369, 8, 35, 13, 4, -29 },
  { 3404, 11, 29, 13, 1, -29 },
  { 3444, 8, 35, 13, 1, -29 },
  { 3479, 19, 18, 23, 2, -29 },
  { 3522, 16, 1, 16, 0, 4 },
  { 3524, 6, 7, 10, 2, -31 },
  { 3530, 15, 21, 20, 2, -21 },
  { 3570, 17, 30, 23, 4, -30 },
  { 3634, 16, 22, 19, 2, -22 },
  { 3678, 18, 30, 23, 2, -30 },
  { 3746, 17, 22, 22, 2, -22 },
  { 3793, 14, 31, 11, 0, -31 },
  { 3848, 18, 32, 23, 2, -22 },
  { 3920, 16, 30, 23, 4, -30 },
  { 3980, 2, 29, 8, 3, -29 },
  { 3988, 7, 39, 8, -2, -29 },
  { 4023, 14, 30, 18, 4, -30 },
  { 4076, 1, 30, 8, 4, -30 },
  { 4080, 27, 22, 34, 4, -22 },
  { 4155, 16, 22, 23, 4, -22 },
  { 4199, 19, 22, 23, 2, -22 },
  { 4252, 17, 31, 23, 4, -22 },
  { 4318, 18, 31, 23, 2, -22 },
  { 4388, 10, 21, 15, 4, -21 },
  { 4415, 14, 22, 18, 2, -22 },
  { 4454, 12, 26, 13, 0, -26 },
  { 4493, 16, 21, 23, 3, -21 },
  { 4535, 17, 21, 17, 0, -21 },
  { 4580, 26, 21, 27, 1, -21 },
  { 4649, 17, 21, 19, 1, -21 },
  { 4694, 17, 31, 17, 0, -21 },
  { 4760, 15, 21, 18, 2, -21 },
  { 4800, 11, 35, 13, 1, -29 },
  { 4849, 1, 41, 21, 10, -31 },
  { 4855, 11, 35, 13, 1, -29 },
  { 4904, 19, 4, 23, 2, -16 },
};

const GFXfont NotoSans_Thin40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin40pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_THIN40PT7B_H_
