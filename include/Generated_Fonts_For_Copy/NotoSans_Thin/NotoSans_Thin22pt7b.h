#ifndef _NOTOSANS_THIN22PT7B_H_
#define _NOTOSANS_THIN22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDB, 0x40, 0x04, 0x20, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x7F, 0xFC, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC,
  0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x08, 0x0F, 0x0A, 0x69,
  0x08, 0x84, 0x42, 0x20, 0x90, 0x38, 0x03, 0x02, 0x41, 0x10, 0x88, 0x44,
  0x23, 0x12, 0x7E, 0x04, 0x00, 0x38, 0x10, 0x88, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x24, 0x10, 0x48, 0x21, 0x26, 0x42, 0x52, 0x45, 0x42, 0x74, 0x84,
  0x09, 0x08, 0x22, 0x10, 0x44, 0x21, 0x08, 0x42, 0x10, 0x88, 0x1E, 0x1F,
  0x00, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x44, 0x01, 0x20, 0x03,
  0x00, 0x34, 0x01, 0x08, 0x28, 0x10, 0xA0, 0x24, 0x80, 0x52, 0x00, 0x84,
  0x05, 0x0F, 0xE3, 0xFC, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x84,
  0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x80,
  0x04, 0x01, 0x00, 0x43, 0x13, 0x37, 0x03, 0x01, 0x20, 0x48, 0x21, 0x00,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x56, 0xA0, 0xF8, 0x80, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x1F, 0x08, 0x24, 0x09, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50,
  0x22, 0x08, 0x7C, 0x08, 0xDB, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x3E, 0x10, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0x3F, 0x30, 0x20,
  0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0xF8, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0B, 0xFC, 0x01, 0x00, 0x20, 0x0A, 0x02, 0x40, 0x88,
  0x11, 0x04, 0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x7F, 0xF0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0xE1, 0x8C,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x05, 0xFC, 0x0F, 0x84, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0xF2, 0xC2, 0x40, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x50, 0x12, 0x08, 0x7C, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x50, 0x23, 0x10, 0x38, 0x33,
  0x10, 0x24, 0x06, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x3E, 0x10, 0x44,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x41, 0xCF, 0x90, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x11, 0xF8, 0xC0, 0x10, 0x50, 0x00, 0x15, 0xA8, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x10,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00, 0xFC, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x86, 0x10, 0x40, 0x81, 0x00, 0x00, 0x00, 0x10, 0x01, 0xF0,
  0x07, 0x06, 0x04, 0x00, 0x84, 0x00, 0x24, 0x00, 0x0A, 0x0F, 0x86, 0x08,
  0x43, 0x08, 0x21, 0x84, 0x10, 0xC4, 0x08, 0x61, 0x04, 0x30, 0x82, 0x18,
  0x42, 0x92, 0x1E, 0x31, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x02, 0x08, 0x10, 0x40, 0xFE, 0x08, 0x08, 0x40, 0x44, 0x01, 0x20, 0x0A,
  0x00, 0x50, 0x01, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B,
  0xFC, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xFC, 0x07,
  0xE1, 0x81, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFE,
  0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x8F, 0xF0, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x07,
  0xF0, 0xC0, 0x48, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x81, 0xFC, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0x90, 0x04, 0x40, 0x21,
  0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF2,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x45, 0xC0, 0x80, 0x60, 0x28, 0x12,
  0x08, 0x84, 0x22, 0x09, 0x02, 0xC0, 0xC8, 0x21, 0x08, 0x42, 0x08, 0x81,
  0x20, 0x28, 0x0A, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0xE8, 0x03, 0xA0, 0x16, 0x80, 0x59, 0x02, 0x64, 0x09,
  0x88, 0x26, 0x21, 0x18, 0x44, 0x61, 0x21, 0x84, 0x86, 0x0A, 0x18, 0x30,
  0x60, 0x41, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C,
  0x21, 0x84, 0x30, 0x46, 0x04, 0xC0, 0x98, 0x0B, 0x00, 0xE0, 0x1C, 0x01,
  0x0F, 0xC0, 0x40, 0xC2, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80,
  0x21, 0x01, 0x03, 0xF8, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0x78, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x0F, 0xC0,
  0x40, 0xC2, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x21, 0x01,
  0x03, 0xD8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0xFE, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0x60, 0x28, 0x0A, 0x04, 0xFE, 0x21, 0x08, 0x22, 0x04,
  0x81, 0x20, 0x28, 0x0A, 0x01, 0x1F, 0x98, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x00, 0xE0, 0x07, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0B,
  0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x43, 0xF8, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x02, 0x40, 0x22, 0x02, 0x20, 0x41, 0x04, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x90, 0x09, 0x00, 0x50, 0x06, 0x00, 0x20, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x50, 0x30, 0x28, 0x14, 0x14, 0x12, 0x0A, 0x09,
  0x08, 0x84, 0x84, 0x42, 0x22, 0x22, 0x12, 0x09, 0x09, 0x04, 0x82, 0x82,
  0x41, 0x41, 0x40, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x10, 0x80, 0x28, 0x08,
  0x81, 0x10, 0x41, 0x10, 0x12, 0x02, 0x80, 0x20, 0x04, 0x01, 0x40, 0x44,
  0x08, 0x42, 0x08, 0x80, 0x90, 0x14, 0x01, 0x80, 0x30, 0x05, 0x01, 0x10,
  0x22, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x07, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xF0, 0x04, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x02,
  0x40, 0x50, 0x04, 0xFF, 0x80, 0x84, 0x21, 0x3E, 0x41, 0x01, 0x01, 0x01,
  0x0F, 0x71, 0x81, 0x81, 0x81, 0x81, 0x7F, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x27, 0x8E, 0x12, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x28, 0x0B, 0x04, 0xBE, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x18, 0x03, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x47, 0xD2, 0x0D, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x05, 0x03, 0x3F, 0x40, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x7F,
  0xF8, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFE, 0x0E, 0x20, 0x81, 0x02,
  0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x1F,
  0x48, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x0C, 0xFD, 0x00, 0x40, 0x10, 0x04, 0x02, 0x7F, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x05, 0xF3, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xCF, 0xFF, 0x11, 0x00, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81,
  0x82, 0x84, 0x88, 0x90, 0xA0, 0xD0, 0x88, 0x84, 0x84, 0x82, 0x81, 0xFF,
  0xFF, 0x80, 0xBC, 0x79, 0x85, 0x0A, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08,
  0x10, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x14, 0x08, 0xFC, 0x9E, 0x38, 0x48, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x2C, 0x12, 0xF8, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1E, 0x48, 0x74, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x50, 0x14, 0x0C, 0xFD, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3E,
  0x41, 0x80, 0x80, 0xC0, 0x30, 0x0E, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x20,
  0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x6F,
  0xD0, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x11, 0x08, 0x88, 0x24, 0x12, 0x0A,
  0x03, 0x01, 0x00, 0x81, 0x03, 0x02, 0x05, 0x06, 0x12, 0x14, 0x24, 0x28,
  0x44, 0x48, 0x89, 0x12, 0x12, 0x24, 0x24, 0x28, 0x30, 0x60, 0x60, 0x40,
  0x80, 0x80, 0x80, 0xC0, 0x90, 0x84, 0x41, 0x40, 0xC0, 0x60, 0x28, 0x22,
  0x21, 0x20, 0x50, 0x10, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x11, 0x08, 0x88,
  0x24, 0x12, 0x0A, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0xE0, 0x00,
  0xFF, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFF,
  0x0C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x23, 0x04, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x81, 0xC0, 0xFF, 0xFF, 0xFE, 0xC0, 0x81, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x31, 0x04, 0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x78, 0x61, 0xF0,
};

const GFXglyph NotoSans_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 3, 6, 7, 2, -16 },
  { 6, 13, 16, 14, 1, -16 },
  { 32, 9, 18, 13, 1, -17 },
  { 53, 15, 16, 17, 1, -16 },
  { 83, 14, 16, 15, 1, -16 },
  { 111, 1, 6, 4, 1, -16 },
  { 112, 4, 19, 6, 1, -16 },
  { 122, 4, 19, 6, 1, -16 },
  { 132, 10, 9, 12, 1, -17 },
  { 144, 10, 10, 13, 1, -13 },
  { 157, 2, 6, 4, 1, -3 },
  { 159, 5, 1, 7, 1, -6 },
  { 160, 1, 1, 5, 2, -1 },
  { 161, 7, 16, 7, 0, -16 },
  { 175, 10, 16, 13, 1, -16 },
  { 195, 5, 16, 13, 2, -16 },
  { 205, 10, 16, 13, 1, -16 },
  { 225, 10, 16, 13, 1, -16 },
  { 245, 11, 16, 13, 1, -16 },
  { 267, 9, 16, 13, 2, -16 },
  { 285, 10, 16, 13, 1, -16 },
  { 305, 10, 16, 13, 1, -16 },
  { 325, 10, 16, 13, 1, -16 },
  { 345, 10, 16, 13, 1, -16 },
  { 365, 1, 12, 5, 2, -12 },
  { 367, 2, 15, 5, 1, -12 },
  { 371, 10, 10, 13, 1, -13 },
  { 384, 10, 5, 13, 1, -10 },
  { 391, 10, 10, 13, 1, -13 },
  { 404, 7, 16, 9, 1, -16 },
  { 418, 17, 18, 19, 1, -16 },
  { 457, 13, 16, 13, 0, -16 },
  { 483, 10, 16, 13, 2, -16 },
  { 503, 12, 16, 14, 1, -16 },
  { 527, 12, 16, 15, 2, -16 },
  { 551, 9, 16, 12, 2, -16 },
  { 569, 9, 16, 11, 2, -16 },
  { 587, 13, 16, 16, 1, -16 },
  { 613, 11, 16, 16, 2, -16 },
  { 635, 4, 16, 6, 1, -16 },
  { 643, 5, 20, 5, -2, -16 },
  { 656, 10, 16, 12, 2, -16 },
  { 676, 9, 16, 11, 2, -16 },
  { 694, 14, 16, 18, 2, -16 },
  { 722, 11, 16, 15, 2, -16 },
  { 744, 14, 16, 17, 1, -16 },
  { 772, 9, 16, 13, 2, -16 },
  { 790, 14, 20, 17, 1, -16 },
  { 825, 10, 16, 13, 2, -16 },
  { 845, 10, 16, 12, 1, -16 },
  { 865, 11, 16, 11, 0, -16 },
  { 887, 12, 16, 16, 2, -16 },
  { 911, 12, 16, 12, 0, -16 },
  { 935, 17, 16, 19, 1, -16 },
  { 969, 11, 16, 11, 0, -16 },
  { 991, 11, 16, 11, 0, -16 },
  { 1013, 11, 16, 13, 1, -16 },
  { 1035, 4, 19, 7, 2, -16 },
  { 1045, 7, 16, 7, 0, -16 },
  { 1059, 4, 19, 7, 1, -16 },
  { 1069, 11, 10, 13, 1, -16 },
  { 1083, 9, 1, 9, 0, 2 },
  { 1085, 4, 4, 5, 1, -17 },
  { 1087, 8, 12, 11, 1, -12 },
  { 1099, 10, 17, 13, 2, -17 },
  { 1121, 9, 12, 10, 1, -12 },
  { 1135, 10, 17, 13, 1, -17 },
  { 1157, 10, 12, 12, 1, -12 },
  { 1172, 7, 17, 6, 0, -17 },
  { 1187, 10, 17, 13, 1, -12 },
  { 1209, 9, 17, 13, 2, -17 },
  { 1229, 1, 16, 5, 2, -16 },
  { 1231, 4, 21, 5, -1, -16 },
  { 1242, 8, 17, 10, 2, -17 },
  { 1259, 1, 17, 5, 2, -17 },
  { 1262, 15, 12, 19, 2, -12 },
  { 1285, 9, 12, 13, 2, -12 },
  { 1299, 10, 12, 13, 1, -12 },
  { 1314, 10, 17, 13, 2, -12 },
  { 1336, 10, 17, 13, 1, -12 },
  { 1358, 6, 12, 8, 2, -12 },
  { 1367, 8, 12, 10, 1, -12 },
  { 1379, 6, 15, 7, 0, -15 },
  { 1391, 9, 12, 13, 2, -12 },
  { 1405, 9, 12, 9, 0, -12 },
  { 1419, 15, 12, 15, 0, -12 },
  { 1442, 9, 12, 11, 1, -12 },
  { 1456, 9, 17, 9, 0, -12 },
  { 1476, 8, 12, 10, 1, -12 },
  { 1488, 6, 19, 7, 1, -16 },
  { 1503, 1, 23, 12, 5, -17 },
  { 1506, 6, 19, 7, 1, -16 },
  { 1521, 10, 2, 13, 1, -9 },
};

const GFXfont NotoSans_Thin22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin22pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_THIN22PT7B_H_
