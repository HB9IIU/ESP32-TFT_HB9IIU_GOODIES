#ifndef _NOTOSANS_THIN30PT7B_H_
#define _NOTOSANS_THIN30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x18, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x07, 0xFF,
  0xFC, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x08, 0x10, 0x3F, 0xFF, 0xC0, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x04,
  0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x00, 0x04, 0x00, 0x40,
  0x1F, 0xC6, 0x42, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x04, 0x40,
  0x24, 0x01, 0xC0, 0x03, 0x00, 0x4C, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x2C, 0x4C, 0x3E, 0x00, 0x40, 0x04, 0x00, 0x38,
  0x00, 0x04, 0x60, 0x10, 0x42, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x08, 0x08, 0x10, 0x80, 0x81, 0x10, 0x08, 0x12, 0x3C,
  0x81, 0x24, 0x28, 0x24, 0x81, 0x46, 0x48, 0x13, 0x88, 0x81, 0x00, 0x88,
  0x10, 0x10, 0x81, 0x01, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x08, 0x04, 0x20, 0x80, 0x3C, 0x07, 0x80, 0x02, 0x18, 0x01, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x40, 0x80,
  0x08, 0xC0, 0x01, 0x40, 0x00, 0x60, 0x00, 0x64, 0x00, 0x20, 0x80, 0x90,
  0x10, 0x28, 0x02, 0x0A, 0x00, 0x44, 0x80, 0x09, 0x20, 0x01, 0x88, 0x00,
  0x61, 0x00, 0x24, 0x60, 0x10, 0x87, 0xF8, 0x30, 0xFE, 0x0C, 0x41, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x82, 0x04, 0x08, 0x30, 0xC2, 0x08, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x82, 0x17, 0x26, 0x0F, 0x80, 0x60, 0x09, 0x00,
  0x88, 0x10, 0x82, 0x04, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x29, 0x25, 0x20, 0xFE, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x00, 0x0F, 0x80, 0x82, 0x08, 0x08,
  0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00,
  0x50, 0x04, 0x40, 0x22, 0x02, 0x0F, 0xE0, 0x06, 0x34, 0x8E, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x0F, 0x01, 0x86, 0x30, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x7F, 0xFC, 0x07, 0x80, 0xE1, 0x84, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0xF8, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x80, 0x11, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x50, 0x00,
  0x50, 0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x3F, 0xF1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x5F, 0x83, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x05, 0x00, 0x47, 0xFC, 0x00,
  0x03, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x7E, 0x2C, 0x0D, 0x80, 0x2C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0A, 0x00, 0x50, 0x02, 0x40, 0x23, 0x03, 0x07, 0xE0,
  0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x0F,
  0x81, 0x83, 0x10, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x20, 0x20, 0xC6, 0x01, 0xC0, 0x31, 0x82, 0x02, 0x20, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x26, 0x02, 0x0F, 0xE0, 0x0F,
  0x01, 0x86, 0x10, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x80, 0x52, 0x0C, 0x8F, 0x84, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x3F, 0x80, 0xC0,
  0x03, 0x24, 0x00, 0x00, 0x00, 0x00, 0x52, 0x4A, 0x40, 0x00, 0x08, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0x3E, 0x30, 0x60, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x30, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0x01,
  0xFF, 0x80, 0x0C, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x90, 0x1F, 0xC1, 0x40, 0x40, 0x81, 0x81, 0x01,
  0x03, 0x04, 0x02, 0x06, 0x08, 0x04, 0x0C, 0x10, 0x08, 0x18, 0x20, 0x10,
  0x30, 0x40, 0x20, 0x60, 0x80, 0xC1, 0x41, 0x01, 0x82, 0x81, 0x0D, 0x89,
  0x00, 0xE0, 0xE1, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x50, 0x00, 0x24, 0x00, 0x22, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x20, 0x04, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x81, 0xFF, 0xC0,
  0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x18, 0x00, 0x08, 0xFF, 0xE2, 0x00, 0x48, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x33, 0xFF, 0x08, 0x06,
  0x20, 0x06, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x0C, 0xFF, 0xC0, 0x01, 0xF0, 0x0C, 0x0C, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x70, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xFC,
  0x03, 0x81, 0xC2, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xF8,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x48, 0x00, 0x22, 0x00, 0x10, 0x80, 0x08, 0x3F, 0xF8, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x4F, 0x80, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x05, 0xF0, 0x80, 0x1E, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x82, 0x04,
  0x08, 0x20, 0x21, 0x00, 0x88, 0x02, 0x60, 0x0A, 0x40, 0x30, 0x80, 0x81,
  0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x80, 0x01, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x20,
  0x02, 0x64, 0x00, 0x4C, 0x40, 0x11, 0x88, 0x02, 0x31, 0x00, 0x46, 0x10,
  0x10, 0xC2, 0x02, 0x18, 0x20, 0x83, 0x04, 0x10, 0x60, 0x42, 0x0C, 0x08,
  0x81, 0x81, 0x10, 0x30, 0x14, 0x06, 0x02, 0x80, 0xC0, 0x20, 0x18, 0x04,
  0x02, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0D, 0x00, 0x19, 0x00, 0x31, 0x00,
  0x62, 0x00, 0xC2, 0x01, 0x82, 0x03, 0x04, 0x06, 0x04, 0x0C, 0x04, 0x18,
  0x08, 0x30, 0x08, 0x60, 0x08, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x16, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x20, 0x01, 0xF0, 0x01, 0xC1, 0x80, 0x40, 0x0C,
  0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x10,
  0x80, 0x02, 0x18, 0x00, 0x80, 0x80, 0x20, 0x0F, 0xF8, 0x00, 0xFF, 0xC8,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0xCF, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xC1, 0x80, 0x40,
  0x0C, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x10, 0x80, 0x02, 0x18, 0x00, 0x80, 0x80, 0x20, 0x0F, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0xFF,
  0xC2, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x88, 0x1C, 0x3F, 0xC0, 0x81, 0x02, 0x02, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x22, 0x00, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0C,
  0x0F, 0xC1, 0x81, 0x90, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x07, 0x00, 0x07, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x7F, 0xC0,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x30, 0x08, 0x0F, 0xF0, 0x80, 0x00,
  0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x40,
  0x10, 0x20, 0x08, 0x10, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x30, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x18, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x20, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x10, 0x42,
  0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x08, 0x81,
  0x10, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x05, 0x00,
  0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x40, 0x06,
  0x40, 0x08, 0x80, 0x20, 0x80, 0x80, 0x81, 0x01, 0x04, 0x01, 0x10, 0x01,
  0x20, 0x02, 0x80, 0x02, 0x00, 0x06, 0x00, 0x14, 0x00, 0x44, 0x00, 0x84,
  0x02, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x20, 0x80, 0x02, 0x80, 0x08, 0x80, 0x11, 0x00, 0x41, 0x00, 0x82,
  0x02, 0x02, 0x08, 0x04, 0x10, 0x04, 0x40, 0x08, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x07, 0xF0, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x44, 0x00,
  0x84, 0x02, 0x08, 0x04, 0x08, 0x10, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x50, 0x00, 0x40, 0xFF, 0xF0, 0x82, 0x08, 0x20, 0x80, 0x1F,
  0xC2, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x7F, 0x18,
  0x16, 0x01, 0x40, 0x18, 0x01, 0x80, 0x34, 0x03, 0x40, 0x53, 0xF9, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0xF0,
  0xA0, 0x66, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x2C, 0x02, 0x70, 0x32, 0x7E,
  0x00, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x23, 0xF9,
  0x20, 0x2A, 0x00, 0xD0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x34, 0x01, 0x90, 0x14, 0x7F,
  0x20, 0x0F, 0x83, 0x06, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x11,
  0xFE, 0x03, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x03, 0xFC, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x1F, 0xC9, 0x01, 0x50, 0x06, 0x80,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xA0, 0x0C, 0x80, 0xA3, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x40, 0x11, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0x4C, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x70, 0x05, 0x55, 0x55, 0x55,
  0x50, 0x04, 0x30, 0x00, 0x00, 0x00, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0xF0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x02, 0x80, 0x90,
  0x22, 0x08, 0x42, 0x08, 0x81, 0x20, 0x24, 0x05, 0x40, 0xC4, 0x10, 0x42,
  0x08, 0x40, 0x88, 0x09, 0x00, 0xA0, 0x18, 0xFF, 0xFF, 0xFE, 0x9F, 0x0F,
  0xCE, 0x09, 0x02, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18,
  0x04, 0x01, 0x9F, 0x8A, 0x04, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x0F, 0xC1, 0x81, 0x10, 0x04, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x00, 0xA0,
  0x08, 0x80, 0x83, 0xF8, 0x9F, 0x85, 0x03, 0x30, 0x05, 0x00, 0x28, 0x01,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28,
  0x01, 0x60, 0x12, 0x81, 0x93, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x1F, 0xC9, 0x01, 0x50, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xA0, 0x0D, 0x80, 0xA3, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x9F, 0xA0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1F, 0xCC, 0x05, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0xF0, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x1B, 0xFC, 0x10, 0x08,
  0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x80, 0x0C, 0x00,
  0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40,
  0x44, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0x40, 0xC0,
  0x20, 0x14, 0x02, 0x01, 0x40, 0x50, 0x14, 0x05, 0x02, 0x20, 0x50, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x41, 0x08, 0x84, 0x11, 0x04, 0x41, 0x10, 0x44,
  0x11, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x80, 0x14, 0x02, 0x20, 0x42, 0x04, 0x10, 0x80, 0x90,
  0x05, 0x00, 0x60, 0x06, 0x00, 0x90, 0x08, 0x81, 0x08, 0x20, 0x42, 0x02,
  0x40, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x10,
  0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x50,
  0x02, 0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x07, 0xFF, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x7C,
  0x0C, 0x18, 0x40, 0x3C,
};

const GFXglyph NotoSans_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 21, 7, 3, -21 },
  { 4, 5, 7, 10, 2, -21 },
  { 9, 18, 21, 19, 1, -21 },
  { 57, 12, 25, 17, 2, -23 },
  { 95, 20, 22, 24, 2, -22 },
  { 150, 18, 22, 21, 2, -22 },
  { 200, 1, 7, 5, 2, -21 },
  { 201, 6, 26, 8, 1, -21 },
  { 221, 5, 26, 8, 1, -21 },
  { 238, 12, 12, 17, 2, -23 },
  { 256, 13, 13, 17, 2, -17 },
  { 278, 3, 7, 5, 1, -3 },
  { 281, 7, 1, 10, 1, -9 },
  { 282, 1, 2, 7, 3, -2 },
  { 283, 9, 21, 10, 0, -21 },
  { 307, 13, 22, 17, 2, -22 },
  { 343, 7, 21, 17, 3, -21 },
  { 362, 13, 22, 17, 2, -22 },
  { 398, 14, 22, 17, 1, -22 },
  { 437, 16, 22, 17, 1, -22 },
  { 481, 13, 21, 17, 2, -21 },
  { 516, 13, 22, 17, 2, -22 },
  { 552, 13, 21, 17, 2, -21 },
  { 587, 13, 22, 17, 2, -22 },
  { 623, 13, 22, 17, 2, -22 },
  { 659, 1, 16, 7, 3, -16 },
  { 661, 3, 20, 7, 1, -16 },
  { 669, 13, 14, 17, 2, -18 },
  { 692, 13, 7, 17, 2, -14 },
  { 704, 13, 14, 17, 2, -18 },
  { 727, 10, 22, 12, 1, -22 },
  { 755, 23, 24, 26, 2, -21 },
  { 824, 17, 21, 17, 0, -21 },
  { 869, 14, 21, 18, 3, -21 },
  { 906, 15, 22, 18, 2, -22 },
  { 948, 16, 21, 21, 3, -21 },
  { 990, 12, 21, 17, 3, -21 },
  { 1022, 12, 21, 15, 3, -21 },
  { 1054, 17, 22, 22, 2, -22 },
  { 1101, 15, 21, 21, 3, -21 },
  { 1141, 5, 21, 8, 2, -21 },
  { 1155, 7, 26, 7, -3, -21 },
  { 1178, 14, 21, 17, 3, -21 },
  { 1215, 12, 21, 15, 3, -21 },
  { 1247, 19, 21, 25, 3, -21 },
  { 1297, 15, 21, 21, 3, -21 },
  { 1337, 19, 22, 23, 2, -22 },
  { 1390, 12, 21, 17, 3, -21 },
  { 1422, 19, 27, 23, 2, -22 },
  { 1487, 14, 21, 17, 3, -21 },
  { 1524, 13, 22, 16, 2, -22 },
  { 1560, 15, 21, 15, 0, -21 },
  { 1600, 16, 21, 21, 3, -21 },
  { 1642, 17, 21, 17, 0, -21 },
  { 1687, 24, 21, 26, 1, -21 },
  { 1750, 15, 21, 15, 0, -21 },
  { 1790, 15, 21, 15, 0, -21 },
  { 1830, 15, 21, 17, 1, -21 },
  { 1870, 6, 26, 9, 3, -21 },
  { 1890, 9, 21, 10, 0, -21 },
  { 1914, 6, 26, 9, 1, -21 },
  { 1934, 15, 14, 17, 1, -22 },
  { 1961, 12, 1, 12, 0, 3 },
  { 1963, 5, 5, 7, 1, -23 },
  { 1967, 12, 16, 15, 1, -16 },
  { 1991, 13, 23, 17, 3, -23 },
  { 2029, 11, 16, 14, 2, -16 },
  { 2051, 13, 23, 17, 2, -23 },
  { 2089, 12, 16, 16, 2, -16 },
  { 2113, 10, 23, 8, 0, -23 },
  { 2142, 13, 23, 17, 2, -16 },
  { 2180, 12, 23, 17, 3, -23 },
  { 2215, 2, 22, 6, 2, -22 },
  { 2221, 6, 29, 6, -2, -22 },
  { 2243, 11, 23, 14, 3, -23 },
  { 2275, 1, 23, 6, 3, -23 },
  { 2278, 20, 16, 26, 3, -16 },
  { 2318, 12, 16, 17, 3, -16 },
  { 2342, 13, 16, 17, 2, -16 },
  { 2368, 13, 23, 17, 3, -16 },
  { 2406, 13, 23, 17, 2, -16 },
  { 2444, 8, 16, 11, 3, -16 },
  { 2460, 11, 16, 14, 1, -16 },
  { 2482, 9, 20, 10, 0, -20 },
  { 2505, 12, 16, 17, 2, -16 },
  { 2529, 13, 16, 13, 0, -16 },
  { 2555, 20, 16, 21, 0, -16 },
  { 2595, 12, 16, 14, 1, -16 },
  { 2619, 13, 23, 13, 0, -16 },
  { 2657, 11, 16, 14, 1, -16 },
  { 2679, 8, 26, 10, 1, -21 },
  { 2705, 1, 31, 16, 7, -23 },
  { 2709, 8, 26, 10, 1, -21 },
  { 2735, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_Thin30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin30pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_THIN30PT7B_H_
