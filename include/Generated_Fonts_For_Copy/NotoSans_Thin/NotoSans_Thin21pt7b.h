#ifndef _NOTOSANS_THIN21PT7B_H_
#define _NOTOSANS_THIN21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0xB6, 0xDA, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x10,
  0x8F, 0xFF, 0x10, 0x81, 0x08, 0x11, 0x0D, 0xFE, 0x21, 0x02, 0x10, 0x21,
  0x02, 0x20, 0x22, 0x00, 0x08, 0x1F, 0x92, 0x11, 0x08, 0x84, 0x41, 0x20,
  0x70, 0x0C, 0x05, 0x82, 0x21, 0x10, 0x88, 0x46, 0x24, 0xFC, 0x08, 0x00,
  0x78, 0x11, 0x10, 0x88, 0x42, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0x53,
  0x91, 0x51, 0x7A, 0x44, 0x0A, 0x10, 0x48, 0x41, 0x21, 0x08, 0x44, 0x21,
  0x11, 0x03, 0x80, 0x1F, 0x01, 0x04, 0x08, 0x20, 0x41, 0x02, 0x10, 0x09,
  0x00, 0x30, 0x06, 0x80, 0x42, 0x0C, 0x08, 0xA0, 0x25, 0x00, 0xC8, 0x02,
  0x20, 0x68, 0xFC, 0x20, 0xF8, 0x32, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x44, 0x23, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x08,
  0x04, 0x02, 0x1D, 0x31, 0xE0, 0x60, 0x48, 0x44, 0x01, 0x00, 0x08, 0x02,
  0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x00, 0x6A, 0x80,
  0xF8, 0x80, 0x04, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x00, 0x3F, 0x10, 0x24, 0x09, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x05, 0x02, 0x40, 0x90, 0x23, 0xF0, 0x19, 0x53, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x3E, 0x20, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0xFE,
  0x7F, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x08, 0x7C, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFC, 0x01, 0x00, 0x60, 0x14, 0x02, 0x80, 0x90,
  0x22, 0x08, 0x41, 0x08, 0x41, 0x10, 0x23, 0xFF, 0x80, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xF8, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x10, 0x0B, 0xF8, 0x1F, 0x88, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x0B, 0xF3, 0x02, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x48,
  0x21, 0xF0, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x3F, 0x10, 0x24,
  0x09, 0x02, 0x40, 0x88, 0x41, 0xA0, 0x58, 0x61, 0x10, 0x28, 0x06, 0x01,
  0x80, 0x50, 0x23, 0xF0, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x05, 0x02, 0x3F, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0xC7, 0xC0, 0x80,
  0x20, 0x40, 0x00, 0x1A, 0xA0, 0x00, 0xC1, 0xC1, 0x80, 0x80, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xC0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00,
  0xFC, 0x04, 0x08, 0x10, 0x20, 0x81, 0x0C, 0x20, 0x40, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x07, 0xF0, 0x08, 0x0C, 0x30, 0x02, 0x20, 0x01, 0x41, 0xE1,
  0x82, 0x11, 0x84, 0x11, 0x88, 0x11, 0x88, 0x11, 0x88, 0x11, 0x88, 0x21,
  0x84, 0x71, 0x83, 0x8E, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xF0,
  0x02, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09, 0x00, 0x88, 0x10, 0x81, 0x08,
  0x20, 0x43, 0xFC, 0x20, 0x24, 0x02, 0x40, 0x28, 0x01, 0x80, 0x10, 0xFF,
  0x20, 0x28, 0x0A, 0x01, 0x80, 0xA0, 0x28, 0x13, 0xFC, 0x80, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x2F, 0xF0, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x60, 0x03, 0xF8, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x03, 0x3F, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xF1, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x1E, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01,
  0x40, 0x13, 0x01, 0x0F, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0F, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xB8, 0x80, 0xE0,
  0x48, 0x22, 0x10, 0x88, 0x24, 0x0B, 0x03, 0x40, 0x88, 0x21, 0x08, 0x22,
  0x08, 0x81, 0x20, 0x28, 0x0C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x0E, 0x00, 0x70,
  0x07, 0x40, 0x3A, 0x02, 0xD0, 0x16, 0x40, 0xB2, 0x09, 0x88, 0x4C, 0x44,
  0x61, 0x23, 0x09, 0x18, 0x50, 0xC1, 0x86, 0x08, 0x20, 0x80, 0x70, 0x1C,
  0x06, 0x81, 0x90, 0x64, 0x18, 0x86, 0x11, 0x82, 0x60, 0x98, 0x16, 0x03,
  0x80, 0xE0, 0x18, 0x04, 0x1F, 0xC1, 0x01, 0x90, 0x04, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14,
  0x01, 0x10, 0x18, 0x7F, 0x00, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0x04, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1F, 0xC1,
  0x01, 0x90, 0x04, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x01, 0x10, 0x18, 0x7D, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x12, 0x08, 0xFC, 0x21, 0x08, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0C,
  0x3F, 0xA0, 0x20, 0x10, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x8F, 0xE0, 0x80,
  0x18, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10,
  0x81, 0x10, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x80,
  0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x28, 0x24, 0x24, 0x12, 0x12, 0x11, 0x09,
  0x08, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x09, 0x09, 0x03, 0x02, 0x81,
  0x81, 0x80, 0xC0, 0x40, 0x20, 0x20, 0xC0, 0x48, 0x08, 0x82, 0x10, 0x81,
  0x10, 0x14, 0x03, 0x00, 0x20, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x44, 0x08,
  0x80, 0xA0, 0x08, 0x80, 0x28, 0x09, 0x02, 0x10, 0x42, 0x10, 0x22, 0x04,
  0x80, 0x50, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x04, 0x03, 0x01, 0x20, 0x48, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80,
  0x40, 0xFF, 0x88, 0x80, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x3F, 0xC1, 0x81,
  0x81, 0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x85, 0xB3, 0x05, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x05, 0x7C, 0x3F, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x49, 0xDD, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05,
  0x02, 0x7F, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0F, 0xFA, 0x01, 0x00, 0x40,
  0x20, 0x0F, 0xE0, 0x1E, 0x40, 0x81, 0x02, 0x1F, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xA0, 0x50, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xA0, 0x4F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x88, 0xB6, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x8F, 0xFE, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88, 0x90,
  0xA0, 0xD0, 0x90, 0x88, 0x84, 0x82, 0x83, 0xFF, 0xFF, 0xFC, 0xFA, 0x0C,
  0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81,
  0x06, 0x04, 0x18, 0x10, 0x40, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x3F, 0x10, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x90, 0x23, 0xF0, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xE0, 0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x3F, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xCF,
  0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x00, 0x7E, 0x80, 0x80, 0x80, 0x60, 0x1C, 0x02, 0x01, 0x01,
  0x01, 0xFE, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D,
  0x80, 0xC0, 0x50, 0x48, 0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x02,
  0x00, 0x81, 0x05, 0x0C, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x88, 0x91, 0x22,
  0x44, 0x8A, 0x14, 0x18, 0x30, 0x60, 0x81, 0x02, 0x00, 0x81, 0x42, 0x44,
  0x24, 0x18, 0x10, 0x18, 0x24, 0x42, 0x81, 0x81, 0x80, 0xC0, 0x50, 0x48,
  0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x41, 0xC0, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80,
  0xFF, 0x19, 0x08, 0x42, 0x10, 0x84, 0x46, 0x10, 0x42, 0x10, 0x84, 0x20,
  0xC0, 0xFF, 0xFF, 0xF8, 0xC0, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x71,
  0x08, 0x20, 0x82, 0x08, 0x23, 0x00, 0xFC, 0x40, 0xE0,
};

const GFXglyph NotoSans_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 5, 2, -15 },
  { 3, 3, 5, 7, 2, -15 },
  { 5, 12, 15, 14, 1, -15 },
  { 28, 9, 17, 12, 1, -16 },
  { 48, 14, 15, 17, 1, -15 },
  { 75, 13, 15, 15, 1, -15 },
  { 100, 1, 5, 4, 1, -15 },
  { 101, 4, 18, 5, 1, -15 },
  { 110, 4, 18, 5, 1, -15 },
  { 119, 9, 9, 12, 1, -16 },
  { 130, 10, 9, 12, 1, -12 },
  { 142, 2, 5, 4, 1, -2 },
  { 144, 5, 1, 7, 1, -6 },
  { 145, 1, 1, 5, 2, -1 },
  { 146, 6, 15, 7, 0, -15 },
  { 158, 10, 15, 12, 1, -15 },
  { 177, 5, 15, 12, 2, -15 },
  { 187, 9, 15, 12, 1, -15 },
  { 204, 9, 15, 12, 1, -15 },
  { 221, 11, 15, 12, 1, -15 },
  { 242, 9, 15, 12, 2, -15 },
  { 259, 10, 15, 12, 1, -15 },
  { 278, 10, 15, 12, 1, -15 },
  { 297, 10, 15, 12, 1, -15 },
  { 316, 10, 15, 12, 1, -15 },
  { 335, 1, 11, 5, 2, -11 },
  { 337, 2, 14, 5, 1, -11 },
  { 341, 10, 9, 12, 1, -12 },
  { 353, 10, 5, 12, 1, -10 },
  { 360, 10, 9, 12, 1, -12 },
  { 372, 7, 15, 9, 1, -15 },
  { 386, 16, 17, 18, 1, -15 },
  { 420, 12, 15, 12, 0, -15 },
  { 443, 10, 15, 13, 2, -15 },
  { 462, 11, 15, 13, 1, -15 },
  { 483, 11, 15, 15, 2, -15 },
  { 504, 8, 15, 12, 2, -15 },
  { 519, 8, 15, 10, 2, -15 },
  { 534, 12, 15, 15, 1, -15 },
  { 557, 11, 15, 15, 2, -15 },
  { 578, 4, 15, 6, 1, -15 },
  { 586, 5, 19, 5, -2, -15 },
  { 598, 10, 15, 12, 2, -15 },
  { 617, 8, 15, 11, 2, -15 },
  { 632, 13, 15, 18, 2, -15 },
  { 657, 10, 15, 15, 2, -15 },
  { 676, 13, 15, 16, 1, -15 },
  { 701, 9, 15, 12, 2, -15 },
  { 718, 13, 19, 16, 1, -15 },
  { 749, 10, 15, 12, 2, -15 },
  { 768, 9, 15, 11, 1, -15 },
  { 785, 11, 15, 11, 0, -15 },
  { 806, 11, 15, 15, 2, -15 },
  { 827, 12, 15, 12, 0, -15 },
  { 850, 17, 15, 18, 1, -15 },
  { 882, 11, 15, 11, 0, -15 },
  { 903, 11, 15, 11, 0, -15 },
  { 924, 10, 15, 12, 1, -15 },
  { 943, 4, 18, 7, 2, -15 },
  { 952, 6, 15, 7, 0, -15 },
  { 964, 4, 18, 7, 1, -15 },
  { 973, 10, 9, 12, 1, -15 },
  { 985, 8, 1, 8, 0, 2 },
  { 986, 3, 3, 5, 1, -16 },
  { 988, 8, 11, 11, 1, -11 },
  { 999, 9, 16, 12, 2, -16 },
  { 1017, 8, 11, 10, 1, -11 },
  { 1028, 9, 16, 12, 1, -16 },
  { 1046, 9, 11, 11, 1, -11 },
  { 1059, 7, 16, 6, 0, -16 },
  { 1073, 9, 16, 12, 1, -11 },
  { 1091, 8, 16, 12, 2, -16 },
  { 1107, 1, 15, 4, 2, -15 },
  { 1109, 4, 20, 4, -1, -15 },
  { 1119, 8, 16, 10, 2, -16 },
  { 1135, 1, 16, 4, 2, -16 },
  { 1137, 14, 11, 18, 2, -11 },
  { 1157, 8, 11, 12, 2, -11 },
  { 1168, 10, 11, 12, 1, -11 },
  { 1182, 9, 16, 12, 2, -11 },
  { 1200, 9, 16, 12, 1, -11 },
  { 1218, 6, 11, 8, 2, -11 },
  { 1227, 8, 11, 10, 1, -11 },
  { 1238, 6, 14, 7, 0, -14 },
  { 1249, 8, 11, 12, 2, -11 },
  { 1260, 9, 11, 9, 0, -11 },
  { 1273, 14, 11, 14, 0, -11 },
  { 1293, 8, 11, 10, 1, -11 },
  { 1304, 9, 16, 9, 0, -11 },
  { 1322, 8, 11, 10, 1, -11 },
  { 1333, 5, 18, 7, 1, -15 },
  { 1345, 1, 21, 11, 5, -16 },
  { 1348, 6, 18, 7, 1, -15 },
  { 1362, 10, 2, 12, 1, -8 },
};

const GFXfont NotoSans_Thin21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin21pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_THIN21PT7B_H_
