#ifndef _NOTOSANS_THIN36PT7B_H_
#define _NOTOSANS_THIN36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x00, 0x80, 0x40, 0x04, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x7F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x04, 0x04,
  0x07, 0xFF, 0xFF, 0x81, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x04,
  0x02, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x3F, 0xE1, 0x88, 0x24, 0x10, 0x08, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x81, 0x00, 0x82, 0x01, 0x04, 0x01, 0x08, 0x01,
  0x90, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x98, 0x01, 0x08, 0x02, 0x08, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x09,
  0xF2, 0xE0, 0x2E, 0x00, 0x08, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x10, 0x21,
  0x00, 0x20, 0x40, 0x80, 0x20, 0x40, 0x80, 0x40, 0x80, 0x40, 0x40, 0x80,
  0x40, 0x80, 0x80, 0x41, 0x80, 0x80, 0x41, 0x00, 0x80, 0x42, 0x00, 0x80,
  0x42, 0x00, 0x80, 0x44, 0x38, 0x80, 0x44, 0xC6, 0x40, 0x88, 0x82, 0x40,
  0x89, 0x01, 0x21, 0x11, 0x01, 0x1E, 0x31, 0x01, 0x00, 0x21, 0x01, 0x00,
  0x41, 0x01, 0x00, 0x41, 0x01, 0x00, 0x81, 0x01, 0x00, 0x81, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x03, 0x06, 0x00, 0x82, 0x04,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x10, 0x20, 0x00, 0x80, 0x40, 0x04, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x04, 0x01, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x40, 0x00, 0x26, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x80, 0x00, 0x21, 0x00, 0x03, 0x02, 0x00, 0x98, 0x04, 0x02, 0x40, 0x08,
  0x0B, 0x00, 0x10, 0x48, 0x00, 0x61, 0x20, 0x00, 0xC8, 0x80, 0x01, 0xE2,
  0x00, 0x03, 0x04, 0x00, 0x0E, 0x18, 0x00, 0xCC, 0x30, 0x06, 0x18, 0x3F,
  0xE0, 0x30, 0xFF, 0xC0, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x81, 0xC0, 0x80, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x60, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x1C, 0x20, 0xC7, 0x5E, 0x01, 0xC0, 0x01,
  0x80, 0x04, 0x80, 0x10, 0x80, 0x41, 0x00, 0x81, 0x02, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x32, 0x22, 0x44, 0x44, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x18, 0x00, 0x07, 0xE0, 0x08, 0x18,
  0x10, 0x04, 0x20, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x20, 0x02, 0x20, 0x02, 0x10, 0x04, 0x18, 0x08, 0x07, 0xF0,
  0x03, 0x05, 0x09, 0x31, 0x61, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x0F, 0xE0, 0x30, 0x10, 0x40, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x30, 0x18, 0xC0, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x80, 0x08, 0x7F, 0xF0, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x10,
  0x02, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x01, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x83, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x3F, 0xFC, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x10, 0xFF,
  0xC0, 0x01, 0xFE, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x41, 0xE0, 0x4C,
  0x1C, 0x90, 0x06, 0xA0, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x02, 0x10,
  0x02, 0x08, 0x0C, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x18,
  0x08, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0x06, 0x30, 0x0C, 0x08, 0x18, 0x06, 0x60, 0x03, 0xC0, 0x0C,
  0x30, 0x10, 0x0C, 0x20, 0x06, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x02, 0x60, 0x02, 0x30, 0x0C, 0x0F,
  0xF0, 0x07, 0xE0, 0x18, 0x10, 0x20, 0x08, 0x40, 0x04, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x40, 0x03, 0x20, 0x05, 0x30, 0x19, 0x0F, 0xE1, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x7F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x33, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x22, 0x26, 0x44, 0x48, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x00, 0x3F,
  0x8C, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x24, 0x00, 0xFF, 0x02, 0x40, 0x30, 0x10, 0x24, 0x04, 0x02,
  0x02, 0x80, 0x80, 0x20, 0x18, 0x08, 0x02, 0x01, 0x80, 0x80, 0x20, 0x18,
  0x10, 0x02, 0x01, 0x81, 0x00, 0x20, 0x18, 0x10, 0x02, 0x02, 0x81, 0x00,
  0x20, 0x28, 0x08, 0x06, 0x02, 0x80, 0x80, 0x60, 0x48, 0x04, 0x09, 0x0C,
  0x40, 0x3F, 0x0F, 0x84, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x10, 0x30, 0x00, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0xFF, 0xF0, 0x08, 0x00, 0x80, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00,
  0x82, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x02, 0x40,
  0x00, 0x14, 0x00, 0x00, 0x40, 0xFF, 0xC0, 0x80, 0x38, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x70, 0x0C, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x20, 0x3F, 0xF8, 0xFF,
  0x00, 0x10, 0x0F, 0x02, 0x00, 0x30, 0x40, 0x01, 0x88, 0x00, 0x11, 0x00,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80, 0x38, 0x1F, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xE8,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0C, 0x01, 0xC1, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x40, 0x00, 0x21, 0x80, 0x01,
  0x07, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13,
  0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x09,
  0xF8, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80,
  0x60, 0x80, 0xC0, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C,
  0x00, 0xB4, 0x00, 0xE2, 0x00, 0xC3, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80,
  0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x02, 0x80, 0x03, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xA0, 0x00, 0x16, 0x80, 0x00, 0x59, 0x00, 0x02, 0x64, 0x00,
  0x09, 0x88, 0x00, 0x26, 0x20, 0x01, 0x18, 0x80, 0x04, 0x61, 0x00, 0x21,
  0x84, 0x00, 0x86, 0x08, 0x02, 0x18, 0x20, 0x10, 0x60, 0x80, 0x41, 0x81,
  0x02, 0x06, 0x04, 0x08, 0x18, 0x08, 0x40, 0x60, 0x21, 0x01, 0x80, 0x84,
  0x06, 0x01, 0x20, 0x18, 0x04, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A,
  0x00, 0x0C, 0x80, 0x06, 0x60, 0x03, 0x10, 0x01, 0x84, 0x00, 0xC3, 0x00,
  0x60, 0x80, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x01, 0x03, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x08, 0x60, 0x02, 0x30, 0x01, 0x18, 0x00, 0x4C,
  0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0xFF, 0x00, 0x06, 0x01, 0x80, 0x30, 0x00, 0x80, 0xC0, 0x00, 0x81, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x02,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x22, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x04, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x90, 0x06, 0x3F, 0xE0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x06, 0x01, 0x80, 0x30, 0x00, 0x80,
  0xC0, 0x00, 0x81, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x01, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x84, 0x00, 0x01, 0x04, 0x00, 0x04, 0x04, 0x00, 0x10,
  0x06, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0xFF,
  0x80, 0x80, 0x70, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x10, 0x81, 0xE0, 0xFE, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x20, 0x80,
  0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x03, 0x07, 0xF8, 0x18, 0x06, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x80, 0x08, 0x7F, 0xF0, 0xFF, 0xFF, 0xC0, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x88, 0x00,
  0x11, 0x80, 0x04, 0x18, 0x03, 0x00, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20,
  0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08, 0x08, 0x01, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x20, 0x20,
  0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x88,
  0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x50, 0x01, 0x40, 0x02,
  0x80, 0x0A, 0x00, 0x24, 0x00, 0x50, 0x01, 0x10, 0x02, 0x40, 0x08, 0x80,
  0x22, 0x00, 0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0x80, 0x20, 0x80, 0x42,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x20, 0x20, 0x80, 0x81, 0x01, 0x04, 0x04,
  0x04, 0x10, 0x10, 0x60, 0x20, 0x80, 0x82, 0x01, 0x04, 0x04, 0x10, 0x04,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x88, 0x01, 0x10, 0x04, 0x40, 0x08, 0x80,
  0x22, 0x00, 0x24, 0x00, 0x90, 0x01, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x28,
  0x00, 0x50, 0x01, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x48, 0x00, 0x22, 0x00, 0x10, 0x40, 0x04, 0x18, 0x02, 0x02,
  0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02, 0x18, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x04, 0x40,
  0x02, 0x10, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x20, 0x10, 0x18, 0x02, 0x04,
  0x00, 0xC2, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x10, 0x80,
  0x00, 0x50, 0x00, 0x34, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x20, 0x10, 0x0C, 0x04, 0x01, 0x02, 0x00, 0x20, 0x80,
  0x08, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xFF, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00, 0x22, 0x00, 0x0B, 0x00,
  0x05, 0x00, 0x01, 0xFF, 0xFC, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x1F,
  0xE3, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x01, 0xF8, 0xF0, 0x48, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1A, 0x03, 0x4F, 0xE2, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x8F, 0xF0,
  0x90, 0x08, 0xA0, 0x04, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xA0, 0x04, 0x90, 0x18, 0x8F, 0xF0,
  0x07, 0xFC, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x0F, 0xF1, 0x18, 0x09, 0x20, 0x05, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x03, 0x40, 0x03, 0x20, 0x05,
  0x10, 0x09, 0x0F, 0xF1, 0x07, 0xF0, 0x30, 0x10, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x30, 0x04, 0x3F, 0xF0, 0x00, 0xC0, 0x33, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF1,
  0x18, 0x09, 0x20, 0x05, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x20, 0x05, 0x10, 0x09, 0x0F, 0xF1,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x40, 0x04, 0x3C, 0x78, 0x03, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F, 0xF1, 0x20,
  0x12, 0x80, 0x16, 0x00, 0x2C, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xF0, 0x02, 0xAA,
  0xAA, 0xAA, 0xAA, 0xA0, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x05, 0x11, 0xC0, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x1A, 0x00, 0x88, 0x06, 0x20, 0x30, 0x80, 0x82, 0x04, 0x08,
  0x20, 0x21, 0x00, 0x8C, 0x02, 0x50, 0x0A, 0x20, 0x30, 0x40, 0x80, 0x82,
  0x02, 0x08, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x8F, 0xE1, 0xFC, 0x58, 0x19, 0x01, 0x28, 0x05, 0x00,
  0x58, 0x01, 0x80, 0x2C, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x8F, 0xF1, 0x20, 0x12, 0x80, 0x16, 0x00, 0x2C, 0x00,
  0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x07, 0xF0, 0x0C, 0x06, 0x08, 0x01, 0x8C, 0x00, 0x44,
  0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0xC0,
  0x04, 0x20, 0x06, 0x0C, 0x06, 0x03, 0xFC, 0x00, 0x87, 0xF0, 0x98, 0x08,
  0xA0, 0x04, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xA0, 0x04, 0x90, 0x08, 0x8F, 0xF0, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x0F, 0xF1, 0x10, 0x09, 0x20, 0x05, 0x40, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x40, 0x03, 0x40, 0x05, 0x20, 0x05,
  0x30, 0x09, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x8F, 0xE4, 0x0A, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0xF8, 0x80, 0x24,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0A, 0x00, 0x67, 0xFE, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x3F, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x1F,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x40, 0x0C, 0x80, 0xD1, 0xFC, 0x40, 0x80, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08,
  0x04, 0x10, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x88,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x03, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xA0, 0x12, 0x01, 0x40, 0x24, 0x02, 0x80,
  0x48, 0x08, 0x80, 0x90, 0x11, 0x02, 0x10, 0x22, 0x04, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x40, 0x88, 0x08, 0x81, 0x10, 0x11, 0x02,
  0x20, 0x22, 0x02, 0x80, 0x28, 0x05, 0x00, 0x50, 0x0A, 0x00, 0xA0, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0xC0, 0x06, 0x80, 0x18, 0x80, 0x20, 0x80,
  0x81, 0x83, 0x01, 0x04, 0x01, 0x10, 0x01, 0x40, 0x02, 0x80, 0x02, 0x00,
  0x0A, 0x00, 0x22, 0x00, 0x46, 0x01, 0x04, 0x04, 0x04, 0x18, 0x0C, 0x20,
  0x08, 0x80, 0x0A, 0x00, 0x08, 0x80, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08, 0x04, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x02, 0x60, 0x07, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xC1, 0xC0, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x03, 0x80, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0E, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x07, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x03, 0x83, 0x80, 0x7F, 0x00, 0xC0,
  0x60, 0xA0, 0x0F, 0x80,
};

const GFXglyph NotoSans_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 6, 10, 12, 3, -26 },
  { 16, 21, 26, 23, 1, -26 },
  { 85, 15, 29, 21, 2, -27 },
  { 140, 24, 26, 29, 2, -26 },
  { 218, 22, 26, 25, 2, -26 },
  { 290, 1, 10, 6, 3, -26 },
  { 292, 6, 32, 9, 2, -26 },
  { 316, 7, 32, 9, 1, -26 },
  { 344, 15, 14, 20, 2, -27 },
  { 371, 17, 17, 21, 2, -21 },
  { 408, 4, 9, 7, 1, -4 },
  { 413, 9, 1, 12, 1, -10 },
  { 415, 2, 2, 8, 3, -2 },
  { 416, 11, 26, 12, 0, -26 },
  { 452, 16, 26, 21, 2, -26 },
  { 504, 8, 26, 21, 4, -26 },
  { 530, 16, 26, 21, 2, -26 },
  { 582, 16, 26, 21, 2, -26 },
  { 634, 19, 26, 21, 1, -26 },
  { 696, 15, 26, 21, 3, -26 },
  { 745, 16, 26, 21, 2, -26 },
  { 797, 16, 26, 21, 2, -26 },
  { 849, 16, 26, 21, 2, -26 },
  { 901, 16, 26, 21, 2, -26 },
  { 953, 2, 19, 8, 3, -19 },
  { 958, 4, 24, 8, 1, -19 },
  { 970, 17, 16, 21, 2, -21 },
  { 1004, 17, 8, 21, 2, -17 },
  { 1021, 17, 16, 21, 2, -21 },
  { 1055, 12, 26, 15, 1, -26 },
  { 1094, 28, 29, 32, 2, -25 },
  { 1196, 21, 26, 21, 0, -26 },
  { 1265, 16, 26, 22, 4, -26 },
  { 1317, 19, 26, 22, 2, -26 },
  { 1379, 19, 26, 25, 4, -26 },
  { 1441, 14, 26, 20, 4, -26 },
  { 1487, 14, 26, 18, 4, -26 },
  { 1533, 21, 26, 26, 2, -26 },
  { 1602, 18, 26, 25, 4, -26 },
  { 1661, 6, 26, 10, 2, -26 },
  { 1681, 9, 32, 8, -4, -26 },
  { 1717, 16, 26, 20, 4, -26 },
  { 1769, 14, 26, 18, 4, -26 },
  { 1815, 22, 26, 30, 4, -26 },
  { 1887, 17, 26, 25, 4, -26 },
  { 1943, 23, 26, 27, 2, -26 },
  { 2018, 15, 26, 21, 4, -26 },
  { 2067, 23, 32, 27, 2, -26 },
  { 2159, 16, 26, 21, 4, -26 },
  { 2211, 16, 26, 20, 2, -26 },
  { 2263, 18, 26, 18, 0, -26 },
  { 2322, 19, 26, 26, 3, -26 },
  { 2384, 20, 26, 20, 0, -26 },
  { 2449, 29, 26, 31, 1, -26 },
  { 2544, 18, 26, 18, 0, -26 },
  { 2603, 18, 26, 18, 0, -26 },
  { 2662, 18, 26, 21, 1, -26 },
  { 2721, 7, 32, 11, 3, -26 },
  { 2749, 11, 26, 12, 0, -26 },
  { 2785, 7, 32, 11, 1, -26 },
  { 2813, 17, 16, 21, 2, -26 },
  { 2847, 14, 1, 14, 0, 3 },
  { 2849, 7, 6, 9, 1, -28 },
  { 2855, 13, 19, 18, 2, -19 },
  { 2886, 16, 27, 21, 3, -27 },
  { 2940, 14, 19, 17, 2, -19 },
  { 2974, 16, 27, 21, 2, -27 },
  { 3028, 15, 19, 19, 2, -19 },
  { 3064, 12, 28, 10, 0, -28 },
  { 3106, 16, 28, 21, 2, -19 },
  { 3162, 15, 27, 21, 3, -27 },
  { 3213, 2, 26, 7, 3, -26 },
  { 3220, 7, 35, 7, -2, -26 },
  { 3251, 14, 27, 16, 3, -27 },
  { 3299, 1, 27, 7, 3, -27 },
  { 3303, 25, 19, 31, 3, -19 },
  { 3363, 15, 19, 21, 3, -19 },
  { 3399, 17, 19, 21, 2, -19 },
  { 3440, 16, 27, 21, 3, -19 },
  { 3494, 16, 27, 21, 2, -19 },
  { 3548, 10, 19, 14, 3, -19 },
  { 3572, 14, 19, 16, 1, -19 },
  { 3606, 10, 24, 11, 0, -24 },
  { 3636, 14, 19, 21, 3, -19 },
  { 3670, 15, 19, 15, 0, -19 },
  { 3706, 23, 19, 25, 1, -19 },
  { 3761, 15, 19, 17, 1, -19 },
  { 3797, 15, 28, 15, 0, -19 },
  { 3850, 14, 19, 16, 1, -19 },
  { 3884, 10, 32, 12, 1, -26 },
  { 3924, 1, 36, 19, 9, -27 },
  { 3929, 10, 32, 12, 1, -26 },
  { 3969, 17, 3, 21, 2, -14 },
};

const GFXfont NotoSans_Thin36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin36pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_THIN36PT7B_H_
