#ifndef _NOTOSANS_THIN8PT7B_H_
#define _NOTOSANS_THIN8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0x32, 0x9E, 0xAF, 0xA8, 0xF2, 0x27, 0xC0, 0x4A, 0xAB,
  0x9D, 0x35, 0x30, 0x72, 0x98, 0xD9, 0xFC, 0xC0, 0x6A, 0xA4, 0x95, 0x58,
  0x2F, 0x60, 0x22, 0xF2, 0xC0, 0xC0, 0x00, 0x55, 0xA0, 0x79, 0x99, 0x97,
  0x75, 0x50, 0x61, 0x12, 0x4F, 0xF1, 0x17, 0x1F, 0x12, 0x59, 0x71, 0xF3,
  0x13, 0xC0, 0xF3, 0x5B, 0xC0, 0xF1, 0x12, 0x24, 0xF7, 0xDB, 0xC0, 0x69,
  0x97, 0x16, 0x00, 0x18, 0x16, 0xC3, 0xFF, 0xC2, 0x3C, 0xE4, 0xA4, 0x00,
  0x3C, 0x86, 0xED, 0x5A, 0xB2, 0x9E, 0x00, 0x23, 0x14, 0xE9, 0x44, 0xF6,
  0xFB, 0xC0, 0x3A, 0x21, 0x08, 0x3C, 0xE9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0,
  0xF2, 0x79, 0x00, 0x3A, 0x21, 0x38, 0xBC, 0x99, 0xF9, 0x99, 0xD5, 0x70,
  0x55, 0x5C, 0xB7, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0x8C, 0x67, 0x3E, 0xD4,
  0x99, 0xDB, 0xB9, 0x7A, 0x18, 0x61, 0x85, 0xE0, 0xD6, 0xE9, 0x00, 0x7A,
  0x18, 0x61, 0x85, 0xA1, 0x80, 0xD6, 0xEB, 0x40, 0x78, 0xC3, 0x1F, 0xF2,
  0x22, 0x22, 0x99, 0x99, 0x9F, 0x8C, 0xA4, 0xA6, 0x10, 0x93, 0x26, 0xB3,
  0x64, 0x49, 0x00, 0x95, 0x24, 0x69, 0x99, 0x64, 0x22, 0x71, 0x24, 0x4F,
  0xFE, 0xA5, 0x50, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0, 0x6E, 0xF0, 0x9A,
  0xDB, 0xC0, 0x78, 0x87, 0x17, 0x99, 0x97, 0xFF, 0x87, 0x79, 0x24, 0x80,
  0xF9, 0x97, 0x1F, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0x97, 0x4D, 0x40, 0xFC,
  0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0xF9, 0x97, 0xF6, 0xF9, 0x00, 0xF9, 0x9F,
  0x11, 0xEA, 0xF8, 0xF0, 0xEA, 0xC0, 0xB6, 0xF0, 0xB5, 0x20, 0xAD, 0x56,
  0xA0, 0xB4, 0x69, 0xB5, 0x25, 0x80, 0x65, 0x70, 0x56, 0x54, 0xFF, 0x95,
  0x5C, 0xF0,
};

const GFXglyph NotoSans_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 6, 5, 1, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 6, 0, -6 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 2, 7, 2, 0, -6 },
  { 24, 4, 3, 4, 0, -6 },
  { 26, 4, 4, 5, 0, -5 },
  { 28, 1, 2, 1, 0, -1 },
  { 29, 2, 1, 3, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 2, 6, 3, 0, -6 },
  { 33, 4, 6, 5, 0, -6 },
  { 36, 2, 6, 5, 1, -6 },
  { 38, 4, 6, 5, 0, -6 },
  { 41, 4, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 1, 4, 2, 0, -4 },
  { 63, 1, 5, 2, 0, -4 },
  { 64, 4, 4, 5, 0, -5 },
  { 66, 4, 2, 5, 0, -4 },
  { 67, 4, 4, 5, 0, -5 },
  { 69, 3, 6, 3, 0, -6 },
  { 72, 7, 7, 7, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 4, 6, 6, 1, -6 },
  { 93, 3, 6, 4, 1, -6 },
  { 96, 3, 6, 4, 1, -6 },
  { 99, 5, 6, 6, 0, -6 },
  { 103, 4, 6, 6, 1, -6 },
  { 106, 2, 6, 2, 0, -6 },
  { 108, 2, 7, 2, -1, -6 },
  { 110, 3, 6, 4, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 5, 6, 7, 1, -6 },
  { 120, 4, 6, 6, 1, -6 },
  { 123, 6, 6, 6, 0, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 6, 7, 6, 0, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 6, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 7, 6, 7, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 4, 6, 5, 0, -6 },
  { 168, 1, 7, 3, 1, -6 },
  { 169, 2, 6, 3, 0, -6 },
  { 171, 2, 7, 3, 0, -6 },
  { 173, 4, 4, 5, 0, -6 },
  { 175, 3, 1, 3, 0, 0 },
  { 176, 2, 1, 2, 0, -6 },
  { 177, 3, 4, 4, 0, -4 },
  { 179, 3, 6, 5, 1, -6 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 4, 6, 5, 0, -6 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 6, 2, 0, -6 },
  { 192, 4, 6, 5, 0, -4 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 1, 6, 2, 0, -6 },
  { 199, 1, 8, 2, 0, -6 },
  { 200, 3, 6, 4, 1, -6 },
  { 203, 1, 6, 2, 0, -6 },
  { 204, 5, 4, 7, 1, -4 },
  { 207, 3, 4, 5, 1, -4 },
  { 209, 4, 4, 5, 0, -4 },
  { 211, 3, 6, 5, 1, -4 },
  { 214, 4, 6, 5, 0, -4 },
  { 217, 2, 4, 3, 1, -4 },
  { 218, 3, 4, 4, 0, -4 },
  { 220, 2, 5, 3, 0, -5 },
  { 222, 3, 4, 5, 1, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 5, 4, 5, 0, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 3, 6, 3, 0, -4 },
  { 234, 3, 4, 4, 0, -4 },
  { 236, 2, 7, 3, 0, -6 },
  { 238, 1, 8, 4, 2, -6 },
  { 239, 2, 7, 3, 0, -6 },
  { 241, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_Thin8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin8pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_THIN8PT7B_H_
