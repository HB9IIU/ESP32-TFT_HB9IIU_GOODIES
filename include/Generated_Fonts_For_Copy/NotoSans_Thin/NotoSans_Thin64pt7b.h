#ifndef _NOTOSANS_THIN64PT7B_H_
#define _NOTOSANS_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x07, 0xF7,
  0x20, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x02, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x02, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0xF0, 0xC0, 0xF0, 0x60, 0x30, 0x04, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x80, 0x00,
  0x0C, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x38, 0x03, 0x07, 0x0F, 0xF0, 0xCF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x60, 0x01, 0xC7, 0x80, 0x00, 0x08, 0x00, 0x60, 0x38, 0x00, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x20, 0x18, 0x00, 0x06, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x10, 0x00, 0x03, 0x00, 0x06,
  0x06, 0x07, 0xE0, 0x60, 0x00, 0xC0, 0x81, 0xFF, 0x0C, 0x00, 0x18, 0x30,
  0x60, 0x30, 0x80, 0x02, 0x0C, 0x18, 0x03, 0x18, 0x00, 0xC1, 0x86, 0x00,
  0x63, 0x00, 0x18, 0x60, 0xC0, 0x06, 0x30, 0x06, 0x0C, 0x30, 0x00, 0xC3,
  0x01, 0x83, 0x06, 0x00, 0x08, 0x78, 0xE0, 0x40, 0xC0, 0x01, 0x03, 0xF8,
  0x18, 0x10, 0x00, 0x30, 0x00, 0x02, 0x02, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x00, 0x06, 0x01, 0x80, 0x04, 0x00, 0x00, 0x70, 0x70, 0x01,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x18, 0x60, 0x01, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC0, 0x00, 0xC6, 0x00, 0x01, 0xC0, 0x01, 0x8C, 0x00, 0x01, 0xC0, 0x06,
  0x10, 0x00, 0x01, 0xC0, 0x0C, 0x60, 0x00, 0x01, 0xC0, 0x10, 0xC0, 0x00,
  0x01, 0xC0, 0x61, 0x80, 0x00, 0x01, 0xC1, 0x83, 0x00, 0x00, 0x01, 0xC3,
  0x06, 0x00, 0x00, 0x01, 0xCC, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x10, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x07,
  0x80, 0x60, 0x00, 0x00, 0x19, 0x80, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x60,
  0x00, 0x03, 0x81, 0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x7C, 0x01, 0xF0,
  0x01, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x07, 0xC0, 0x10, 0x07, 0x9F, 0x02, 0x07,
  0xC0, 0x7C, 0x47, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x00, 0xFF, 0xFE,
  0x7F, 0x72, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x1A, 0x01, 0x90, 0x38, 0x83, 0x84, 0x70,
  0x27, 0x01, 0x70, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x1E, 0x00, 0x78,
  0x00, 0x60, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x1E,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x70, 0x7E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x33, 0xFF, 0xE0,
  0x07, 0xFC, 0x1F, 0x80, 0x60, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x07, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xF8, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x07, 0xFC, 0x00, 0x81, 0xFF, 0xF8, 0x04, 0x3C, 0x00, 0x70,
  0x23, 0x80, 0x00, 0xC3, 0x30, 0x00, 0x03, 0x1B, 0x00, 0x00, 0x0C, 0xD0,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0D, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x7D, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F,
  0x60, 0x00, 0x01, 0xB3, 0x00, 0x00, 0x33, 0x18, 0x00, 0x07, 0x30, 0xE0,
  0x01, 0xC3, 0x07, 0xC0, 0xF8, 0x30, 0x1F, 0xFE, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF7, 0x20, 0x0C, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x61, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x03, 0xF8, 0x1E, 0x06, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x41, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x18, 0xC0, 0x00,
  0x60, 0x00, 0x80, 0x06, 0x30, 0x00, 0x70, 0x00, 0x20, 0x00, 0x98, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0D, 0x80,
  0x06, 0x00, 0x01, 0x80, 0x03, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0xD0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x34, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x08, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x02, 0x00, 0x00, 0x60,
  0x00, 0xB0, 0x00, 0x80, 0x00, 0x38, 0x00, 0x64, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x19, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x04, 0x60, 0x03, 0x00, 0x01,
  0xE0, 0x03, 0x18, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x86, 0x00, 0x1C, 0x00,
  0x63, 0x00, 0x61, 0x80, 0x03, 0x80, 0x30, 0xC0, 0x30, 0x30, 0x00, 0x7E,
  0xF8, 0x1F, 0xF8, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x0F, 0x81, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x03, 0xE0, 0x80, 0x00, 0x03, 0x84, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x0E,
  0x20, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x10, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x20, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x00,
  0x1C, 0x04, 0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x00, 0xE0, 0x20, 0x00,
  0x01, 0xC0, 0x10, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x20, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x3F, 0xF8, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08,
  0x3C, 0x00, 0x00, 0x43, 0x30, 0x00, 0x02, 0x31, 0xC0, 0x00, 0x13, 0x06,
  0x00, 0x00, 0xB0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80,
  0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0xC0, 0x02,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00,
  0x03, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x07, 0x02, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x1C, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x00, 0x0F,
  0xB0, 0x00, 0x00, 0x00, 0x0B, 0x90, 0x00, 0x00, 0x00, 0x1B, 0x98, 0x00,
  0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x00, 0x33, 0x8C, 0x00, 0x00, 0x00,
  0x33, 0x8C, 0x00, 0x00, 0x00, 0x23, 0x84, 0x00, 0x00, 0x00, 0x63, 0x86,
  0x00, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00,
  0x00, 0xC3, 0x83, 0x00, 0x00, 0x00, 0x83, 0x81, 0x00, 0x00, 0x01, 0x83,
  0x81, 0x80, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00, 0x03, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x80, 0x60, 0x00, 0x04, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00,
  0x18, 0x03, 0x80, 0x18, 0x00, 0x10, 0x03, 0x80, 0x08, 0x00, 0x30, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x40, 0x03, 0x80, 0x02, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x01, 0x80, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x80, 0x01, 0x83, 0x00, 0x03, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x0F, 0x82, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xE2, 0x00, 0x00, 0xE0, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xE0,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00,
  0xF8, 0x08, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x07, 0x08, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x38, 0x08,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x80, 0x03,
  0x80, 0x08, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x07, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0E,
  0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0x0F, 0xF0, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x07,
  0x0F, 0xC0, 0x07, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1D, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x0C,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20, 0x04, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0xF8, 0x1E, 0x00, 0x1C,
  0x08, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF9, 0x03, 0xC0, 0x01, 0x0E, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x30, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x60, 0x00, 0x09, 0x60, 0x00, 0x19,
  0x38, 0x00, 0x71, 0x1E, 0x01, 0xC1, 0x07, 0xFF, 0x81, 0x00, 0x70, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x08, 0x0F, 0xFF, 0x00, 0x83, 0xE0, 0x78, 0x08,
  0x70, 0x00, 0xE0, 0x8C, 0x00, 0x07, 0x09, 0x80, 0x00, 0x30, 0xB0, 0x00,
  0x01, 0x8B, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0C, 0xA0, 0x00, 0x01, 0x8B, 0x00, 0x00, 0x18, 0x90, 0x00,
  0x03, 0x09, 0x80, 0x00, 0x60, 0x8E, 0x00, 0x1C, 0x08, 0x78, 0x07, 0x80,
  0x81, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xF8,
  0x0F, 0x01, 0xC0, 0x01, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x01, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x03,
  0x01, 0xE0, 0x7C, 0x30, 0x70, 0x00, 0xE3, 0x0E, 0x00, 0x03, 0x31, 0xC0,
  0x00, 0x1B, 0x18, 0x00, 0x01, 0xB3, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x00,
  0xF6, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x74, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x74, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x00, 0xF3, 0x00,
  0x00, 0x1B, 0x18, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x33, 0x0E, 0x00, 0x06,
  0x30, 0x3C, 0x03, 0xC3, 0x00, 0xFF, 0xF0, 0x30, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x04, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x20, 0x3E,
  0x0F, 0x84, 0x1C, 0x00, 0x18, 0x87, 0x00, 0x01, 0x91, 0xC0, 0x00, 0x1A,
  0x30, 0x00, 0x01, 0x4C, 0x00, 0x00, 0x39, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1A, 0x30, 0x00, 0x03,
  0x43, 0x00, 0x00, 0xC8, 0x30, 0x00, 0x71, 0x03, 0xC0, 0x3C, 0x20, 0x1F,
  0xFE, 0x04, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x80, 0xFE, 0x03,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x01, 0xFF, 0xC0, 0x83, 0xE0, 0x78, 0x43, 0x80,
  0x0E, 0x23, 0x00, 0x01, 0x93, 0x00, 0x00, 0x6B, 0x00, 0x00, 0x35, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0xFF, 0xB0, 0x00, 0x00, 0x04, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x43, 0x8F, 0xE0, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00,
  0x62, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x20, 0x01, 0xC0, 0x40, 0x07, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x02,
  0x00, 0xC0, 0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x20,
  0xF0, 0x00, 0x43, 0x60, 0x00, 0x8C, 0x60, 0x01, 0x30, 0x60, 0x02, 0x60,
  0x60, 0x05, 0x80, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x20, 0x00,
  0xC0, 0x40, 0x01, 0x80, 0x80, 0x01, 0x81, 0x00, 0x01, 0x82, 0x00, 0x01,
  0x84, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20, 0x00, 0x03,
  0x40, 0x00, 0x06, 0x80, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x10, 0xF0, 0x3C, 0x07, 0x81, 0xC2,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x4C, 0x00, 0x18, 0x60, 0x00, 0xCB, 0x00,
  0x01, 0x98, 0x00, 0x0D, 0x40, 0x00, 0x16, 0x00, 0x00, 0xB8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x80, 0xFF, 0xE0, 0x41, 0xF0, 0x3C, 0x21, 0xC0,
  0x07, 0x11, 0x80, 0x00, 0xC9, 0x80, 0x00, 0x35, 0x80, 0x00, 0x1A, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x7F,
  0xF0, 0x08, 0x1E, 0x07, 0xC0, 0x87, 0x00, 0x0E, 0x08, 0xE0, 0x00, 0x70,
  0x9C, 0x00, 0x03, 0x89, 0x80, 0x00, 0x18, 0xB0, 0x00, 0x00, 0xCA, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x04, 0xE0, 0x00, 0x00, 0xCB, 0x00, 0x00, 0x08,
  0xB0, 0x00, 0x01, 0x89, 0x80, 0x00, 0x30, 0x8C, 0x00, 0x06, 0x08, 0xE0,
  0x00, 0xE0, 0x83, 0xC0, 0x78, 0x08, 0x1F, 0xFE, 0x00, 0x80, 0x0F, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x20, 0x3C, 0x0F, 0x04, 0x1C, 0x00, 0x38,
  0x86, 0x00, 0x03, 0x91, 0x80, 0x00, 0x32, 0x30, 0x00, 0x03, 0x4C, 0x00,
  0x00, 0x2B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x53, 0x00, 0x00, 0x1A, 0x70, 0x00, 0x06, 0x47, 0x00, 0x01, 0x88, 0x70,
  0x00, 0x61, 0x07, 0x80, 0x38, 0x20, 0x3F, 0xFC, 0x04, 0x00, 0x7C, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x81, 0xFF, 0xC3, 0xE0, 0xE3, 0x80, 0x13, 0x00, 0x09, 0x00, 0x05, 0x80,
  0x02, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x7E, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x1C, 0x7C, 0x00, 0x78, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x40, 0x3F, 0xF0, 0x01, 0xC0, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x74,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x02, 0xCC, 0x00, 0x01,
  0xB3, 0x80, 0x00, 0xCC, 0x70, 0x00, 0xE3, 0x0F, 0x00, 0xF0, 0xC0, 0xFF,
  0xF0, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x04,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x40, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x26, 0x00, 0x00, 0xE0, 0x00, 0x09, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x43,
  0x00, 0x01, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0x80, 0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0x81, 0x80, 0x06, 0x08,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x06,
  0x03, 0x00, 0x30, 0x10, 0x01, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x02, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x80, 0x60,
  0x0C, 0x02, 0x00, 0x60, 0x10, 0x03, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x84,
  0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x20, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x02, 0x40,
  0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x40, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x80, 0x01, 0x80, 0x10, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x08, 0x70, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x80, 0x0F, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0B, 0xC1, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE3, 0xC8,
  0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph NotoSans_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 47, 14, 5, -46 },
  { 25, 11, 17, 20, 5, -46 },
  { 49, 38, 46, 41, 2, -46 },
  { 268, 26, 53, 36, 4, -49 },
  { 441, 43, 47, 51, 4, -46 },
  { 694, 39, 47, 45, 4, -46 },
  { 924, 1, 17, 11, 5, -46 },
  { 927, 11, 56, 16, 3, -46 },
  { 1004, 12, 56, 16, 2, -46 },
  { 1088, 27, 26, 35, 4, -49 },
  { 1176, 29, 29, 36, 4, -37 },
  { 1282, 6, 15, 12, 2, -7 },
  { 1294, 15, 1, 21, 3, -18 },
  { 1296, 4, 4, 14, 5, -3 },
  { 1298, 19, 46, 21, 1, -46 },
  { 1408, 28, 47, 36, 4, -46 },
  { 1573, 13, 46, 36, 7, -46 },
  { 1648, 27, 46, 36, 4, -46 },
  { 1804, 28, 47, 36, 3, -46 },
  { 1969, 34, 46, 36, 2, -46 },
  { 2165, 27, 47, 36, 5, -46 },
  { 2324, 29, 47, 36, 4, -46 },
  { 2495, 29, 46, 36, 4, -46 },
  { 2662, 28, 47, 36, 4, -46 },
  { 2827, 28, 47, 36, 4, -46 },
  { 2992, 4, 35, 14, 5, -34 },
  { 3010, 7, 42, 14, 2, -34 },
  { 3047, 29, 29, 36, 4, -38 },
  { 3153, 29, 15, 36, 4, -30 },
  { 3208, 29, 29, 36, 4, -38 },
  { 3314, 22, 47, 26, 2, -46 },
  { 3444, 50, 51, 56, 3, -45 },
  { 3763, 37, 46, 37, 0, -46 },
  { 3976, 29, 46, 39, 7, -46 },
  { 4143, 33, 47, 39, 4, -46 },
  { 4337, 33, 46, 44, 7, -46 },
  { 4527, 24, 46, 35, 7, -46 },
  { 4665, 24, 46, 31, 7, -46 },
  { 4803, 37, 47, 46, 4, -46 },
  { 5021, 32, 46, 45, 7, -46 },
  { 5205, 10, 46, 18, 4, -46 },
  { 5263, 14, 57, 15, -6, -46 },
  { 5363, 29, 46, 36, 7, -46 },
  { 5530, 24, 46, 32, 7, -46 },
  { 5668, 40, 46, 54, 7, -46 },
  { 5898, 31, 46, 45, 7, -46 },
  { 6077, 40, 47, 48, 4, -46 },
  { 6312, 26, 46, 37, 7, -46 },
  { 6462, 40, 57, 48, 4, -46 },
  { 6747, 28, 46, 37, 7, -46 },
  { 6908, 27, 47, 35, 4, -46 },
  { 7067, 32, 46, 32, 0, -46 },
  { 7251, 34, 47, 46, 6, -46 },
  { 7451, 36, 46, 36, 0, -46 },
  { 7658, 52, 46, 56, 2, -46 },
  { 7957, 33, 46, 33, 0, -46 },
  { 8147, 32, 46, 32, 0, -46 },
  { 8331, 32, 46, 37, 2, -46 },
  { 8515, 12, 56, 20, 6, -46 },
  { 8599, 19, 46, 21, 1, -46 },
  { 8709, 12, 56, 20, 2, -46 },
  { 8793, 31, 28, 36, 3, -46 },
  { 8902, 25, 1, 25, 0, 6 },
  { 8906, 10, 10, 16, 3, -49 },
  { 8919, 24, 35, 33, 3, -34 },
  { 9024, 28, 50, 37, 6, -49 },
  { 9199, 24, 35, 30, 4, -34 },
  { 9304, 28, 50, 37, 4, -49 },
  { 9479, 27, 35, 35, 4, -34 },
  { 9598, 21, 49, 18, 1, -49 },
  { 9727, 27, 49, 37, 4, -34 },
  { 9893, 25, 49, 37, 6, -49 },
  { 10047, 3, 46, 13, 5, -46 },
  { 10065, 11, 61, 13, -3, -46 },
  { 10149, 23, 49, 29, 6, -49 },
  { 10290, 1, 49, 13, 6, -49 },
  { 10297, 43, 34, 55, 6, -34 },
  { 10480, 25, 34, 37, 6, -34 },
  { 10587, 29, 35, 37, 4, -34 },
  { 10714, 28, 49, 37, 6, -34 },
  { 10886, 27, 49, 37, 4, -34 },
  { 11052, 17, 34, 24, 6, -34 },
  { 11125, 24, 35, 29, 2, -34 },
  { 11230, 18, 43, 20, 1, -42 },
  { 11327, 26, 35, 37, 5, -34 },
  { 11441, 28, 34, 28, 0, -34 },
  { 11560, 42, 34, 44, 1, -34 },
  { 11739, 27, 34, 31, 2, -34 },
  { 11854, 28, 50, 27, 0, -34 },
  { 12029, 24, 34, 29, 3, -34 },
  { 12131, 17, 56, 22, 2, -46 },
  { 12250, 2, 65, 34, 16, -49 },
  { 12267, 18, 56, 22, 2, -46 },
  { 12393, 29, 5, 36, 4, -25 },
};

const GFXfont NotoSans_Thin64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin64pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_THIN64PT7B_H_
