#ifndef _NOTOSANS_THIN53PT7B_H_
#define _NOTOSANS_THIN53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x00, 0x00, 0x3E, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x10, 0x01, 0x00, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xE0, 0x0E, 0x31, 0xF0, 0x60, 0xC0, 0x43, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x40, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xE3, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x78, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x70, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x80, 0x30, 0x61, 0xE0, 0xC7,
  0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x01, 0x83, 0x00, 0x01, 0x80,
  0x30, 0x18, 0x00, 0x30, 0x02, 0x00, 0x80, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x08, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x10, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x06, 0x04,
  0x00, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x06, 0x08, 0x00, 0x0C, 0x00,
  0x41, 0x83, 0xF0, 0x40, 0x04, 0x10, 0xE1, 0x84, 0x00, 0xC3, 0x18, 0x0C,
  0x60, 0x0C, 0x21, 0x80, 0x42, 0x00, 0x86, 0x30, 0x06, 0x30, 0x18, 0x43,
  0x00, 0x21, 0x83, 0x08, 0x20, 0x02, 0x0F, 0xE1, 0x82, 0x00, 0x30, 0x00,
  0x10, 0x20, 0x03, 0x00, 0x03, 0x06, 0x00, 0x30, 0x00, 0x20, 0x60, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x30, 0x00, 0x40, 0x60, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0x10, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x00,
  0xC1, 0x80, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x47, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x02, 0x30, 0x01, 0x80, 0x06, 0x20, 0x00, 0xC0, 0x06, 0x60,
  0x00, 0x60, 0x04, 0x40, 0x00, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0x08, 0xC0,
  0x00, 0x0C, 0x18, 0xC0, 0x00, 0x06, 0x10, 0xC0, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x01, 0xE0, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xE0, 0x20,
  0x00, 0x03, 0x30, 0x30, 0x00, 0x06, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x0E,
  0x00, 0x70, 0x06, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x70, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x06, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x20,
  0x08, 0x02, 0xF8, 0x10, 0x3E, 0x1E, 0x23, 0xC0, 0x07, 0x7C, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0x41,
  0x00, 0x01, 0x03, 0x00, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x20, 0x02,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x84, 0x63, 0x10, 0x8C, 0x62, 0x11, 0x88,
  0x00, 0xFF, 0xF8, 0x7D, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x10, 0x06, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x07, 0x01, 0xD0, 0x31, 0x06, 0x11, 0xC1, 0x30,
  0x1E, 0x01, 0x40, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x03,
  0xFF, 0x00, 0x1C, 0x03, 0x00, 0xE0, 0x01, 0x83, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x60, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0x78, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x68, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x50, 0x00, 0x7F, 0xFF, 0x80, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x07, 0x0F,
  0x00, 0x3C, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xC0, 0x10, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0xFF, 0xC0, 0x87, 0x80, 0xE1, 0x18, 0x00,
  0x62, 0x60, 0x00, 0x65, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0,
  0x00, 0x01, 0xB0, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x10, 0x60,
  0x00, 0x60, 0x60, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x18,
  0x00, 0x10, 0x0E, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0xE3, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x01, 0xC0, 0x1C,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x20, 0x00, 0x18, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x07, 0x40, 0x00, 0x0E, 0x60,
  0x00, 0x0A, 0x30, 0x00, 0x12, 0x18, 0x00, 0x62, 0x0E, 0x01, 0xC2, 0x03,
  0xFF, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xB0, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x62, 0x11, 0x8C, 0x42, 0x31, 0x88, 0x46, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x3C, 0x03, 0x88, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x84, 0x00, 0x1F,
  0xFF, 0x00, 0x66, 0x00, 0x18, 0x01, 0x80, 0x13, 0x00, 0x18, 0x00, 0xC0,
  0x09, 0x00, 0x18, 0x00, 0x60, 0x05, 0x80, 0x18, 0x00, 0x30, 0x03, 0xC0,
  0x08, 0x00, 0x10, 0x01, 0xE0, 0x0C, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x00,
  0x04, 0x00, 0x70, 0x02, 0x00, 0x02, 0x00, 0x38, 0x01, 0x00, 0x01, 0x00,
  0x1C, 0x00, 0x80, 0x00, 0x80, 0x0E, 0x00, 0x40, 0x00, 0x40, 0x05, 0x00,
  0x20, 0x00, 0x60, 0x02, 0x80, 0x10, 0x00, 0x30, 0x01, 0x40, 0x0C, 0x00,
  0x18, 0x01, 0xB0, 0x06, 0x00, 0x1C, 0x00, 0x98, 0x01, 0x00, 0x0B, 0x00,
  0xCC, 0x00, 0xC0, 0x08, 0x80, 0xC2, 0x00, 0x38, 0x18, 0x60, 0xC1, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x60, 0x1F, 0xF0, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x60,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x3E,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x00, 0x10, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00,
  0x0C, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0xFF,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC8, 0x38, 0xFF, 0x00, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x63, 0x60,
  0x00, 0x33, 0x10, 0x00, 0x1B, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x17, 0xC0, 0x00, 0x00,
  0x0F, 0xD0, 0x00, 0x00, 0x02, 0xF6, 0x00, 0x00, 0x00, 0xBC, 0x80, 0x00,
  0x00, 0x6F, 0x30, 0x00, 0x00, 0x13, 0xC4, 0x00, 0x00, 0x0C, 0xF1, 0x80,
  0x00, 0x02, 0x3C, 0x60, 0x00, 0x01, 0x8F, 0x08, 0x00, 0x00, 0x63, 0xC3,
  0x00, 0x00, 0x10, 0xF0, 0x40, 0x00, 0x0C, 0x3C, 0x18, 0x00, 0x02, 0x0F,
  0x06, 0x00, 0x01, 0x83, 0xC0, 0x80, 0x00, 0x60, 0xF0, 0x30, 0x00, 0x10,
  0x3C, 0x04, 0x00, 0x0C, 0x0F, 0x01, 0x80, 0x02, 0x03, 0xC0, 0x60, 0x01,
  0x80, 0xF0, 0x08, 0x00, 0x40, 0x3C, 0x03, 0x00, 0x10, 0x0F, 0x00, 0x40,
  0x0C, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xF0, 0x02, 0x01, 0x80, 0x3C, 0x00,
  0x80, 0x40, 0x0F, 0x00, 0x30, 0x10, 0x03, 0xC0, 0x04, 0x0C, 0x00, 0xF0,
  0x01, 0x82, 0x00, 0x3C, 0x00, 0x21, 0x80, 0x0F, 0x00, 0x08, 0x40, 0x03,
  0xC0, 0x03, 0x30, 0x00, 0xF0, 0x00, 0x4C, 0x00, 0x3C, 0x00, 0x1A, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x02, 0x00,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x02, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x02, 0x01, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x02, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x02, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0x01, 0xFE, 0x0C, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x30, 0x00, 0x70, 0xC0,
  0x7F, 0x03, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x00,
  0xC0, 0x7F, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0xC0, 0x07, 0x80, 0xFF, 0xFC, 0x00,
  0xC0, 0x04, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0xF8, 0x70, 0x00, 0x11,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x64, 0x00, 0x01, 0x8F, 0x00,
  0x1C, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x00, 0x80, 0x00, 0x40, 0x03, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x16, 0x00, 0x00, 0x98,
  0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x18, 0x80, 0x00,
  0xCC, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0xC1, 0x00, 0x06, 0x10, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x80, 0x02, 0x06, 0x00, 0x10, 0x20, 0x01, 0x80, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x20, 0x02, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x80,
  0x40, 0x0C, 0x03, 0x00, 0x60, 0x10, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x06, 0x01, 0x00, 0x20, 0x18, 0x00,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x20, 0x30, 0x03, 0x01, 0x00, 0x0C, 0x08,
  0x00, 0x40, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x41, 0x80, 0x06,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x21, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x23, 0x00, 0x03, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x4C, 0x00, 0x03, 0x20, 0x00, 0x13, 0x00, 0x00, 0x58, 0x00,
  0x06, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x28,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x08, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x80, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x64, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x20, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x08, 0x60, 0x00, 0x06, 0x08, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x00, 0x18, 0x02, 0x00, 0x04, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80, 0x10,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x07, 0xFF, 0x03, 0xC0, 0x38, 0x30, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0F, 0xF0,
  0x3F, 0xFB, 0x0E, 0x00, 0x33, 0x80, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x01, 0xB6, 0x00, 0x33, 0x30, 0x0E, 0x31, 0xFF,
  0x83, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x08, 0x3F, 0xF8, 0x10, 0xC0, 0x18, 0x27, 0x00, 0x18, 0x48,
  0x00, 0x18, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x80, 0x00, 0x65, 0x00, 0x00, 0x8B,
  0x00, 0x03, 0x13, 0x00, 0x0C, 0x23, 0x80, 0x70, 0x41, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x03, 0x80, 0x10, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x03,
  0x01, 0xFF, 0xE0, 0x01, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x40, 0x10, 0x1F, 0xF8, 0x20, 0xE0, 0x1C, 0x43, 0x00, 0x0C,
  0x8C, 0x00, 0x0D, 0x30, 0x00, 0x0A, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x39, 0x80, 0x00,
  0x51, 0x80, 0x01, 0xA3, 0x80, 0x06, 0x41, 0xC0, 0x38, 0x81, 0xFF, 0xC1,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x70, 0x0C, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x40, 0x00, 0x63, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x41, 0xC0, 0x0E, 0x01, 0xFF, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x84,
  0x1C, 0x03, 0x88, 0x60, 0x01, 0x91, 0x80, 0x01, 0xA6, 0x00, 0x01, 0x48,
  0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0x90, 0x00, 0x05, 0x30, 0x00, 0x0A, 0x30, 0x00, 0x24, 0x30, 0x00, 0xC8,
  0x38, 0x07, 0x10, 0x3F, 0xF8, 0x20, 0x02, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x1C, 0x00,
  0x30, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x20, 0x08, 0x3F, 0xF0, 0x47, 0x00, 0xE2, 0x60, 0x01, 0x96, 0x00,
  0x06, 0xA0, 0x00, 0x37, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x03, 0x3F, 0x83, 0x80, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x0D, 0x00, 0x03, 0x20, 0x00, 0xC4, 0x00,
  0x30, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x06,
  0x01, 0x01, 0x80, 0x20, 0x60, 0x04, 0x18, 0x00, 0x87, 0x00, 0x11, 0xB0,
  0x02, 0x62, 0x00, 0x48, 0x60, 0x0A, 0x06, 0x01, 0x80, 0x40, 0x30, 0x04,
  0x04, 0x00, 0xC0, 0x80, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01,
  0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x10, 0x08, 0x7F, 0xC0, 0x3F, 0xF0,
  0x8E, 0x07, 0x07, 0x01, 0x89, 0x80, 0x18, 0xC0, 0x0C, 0xB0, 0x00, 0x98,
  0x00, 0x6E, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x2C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x04, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x04, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x10, 0x04, 0x1F, 0xF8, 0x23, 0x80, 0x71, 0x30, 0x00,
  0xC9, 0x00, 0x03, 0x50, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x01, 0x03, 0xFF, 0x02, 0x1C, 0x03, 0x04, 0x60, 0x03,
  0x09, 0x80, 0x01, 0x16, 0x00, 0x03, 0x28, 0x00, 0x02, 0x70, 0x00, 0x06,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x58, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x04, 0xA0, 0x00,
  0x19, 0x60, 0x00, 0x62, 0x60, 0x01, 0x84, 0x70, 0x0E, 0x08, 0x3F, 0xF0,
  0x10, 0x02, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0x04, 0x1C, 0x03, 0x88, 0x60, 0x01, 0x91, 0x80,
  0x01, 0x26, 0x00, 0x01, 0x48, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x40, 0x00,
  0x06, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x05, 0x30, 0x00, 0x1A, 0x20,
  0x00, 0x64, 0x60, 0x01, 0x88, 0x70, 0x06, 0x10, 0x3F, 0xF8, 0x20, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x87, 0xFE, 0x30,
  0x09, 0x80, 0x2C, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFC, 0x1C, 0x00, 0xE3, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x80, 0x00, 0xCF, 0x00, 0x38, 0x3F, 0xFE, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x3F, 0xFF, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x3F, 0xC0, 0x08, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x74, 0x00, 0x01, 0xD8, 0x00, 0x0B, 0x20, 0x00,
  0x6C, 0xC0, 0x03, 0x31, 0xC0, 0x38, 0xC1, 0xFF, 0x83, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x01, 0x80, 0x60, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x20, 0x01, 0x00, 0xC0, 0x03, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x98, 0x00, 0x64, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x18, 0x80, 0x04, 0x60, 0x04, 0x30, 0x03, 0x18, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x08,
  0x18, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x06, 0x00,
  0xC3, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x18, 0x40, 0x04, 0x20, 0x02, 0x30,
  0x01, 0x88, 0x00, 0x88, 0x00, 0x26, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x03, 0x40, 0x01, 0x40, 0x00, 0x50, 0x00, 0x50, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x46, 0x00, 0x01, 0x04, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x18, 0x04, 0x00, 0x18, 0x18, 0x00, 0x10, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x42, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x01,
  0x80, 0x60, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x20,
  0x01, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x10, 0x00, 0x08, 0x60, 0x00, 0x18, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x68, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x6E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0C,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0x70, 0xF0, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x60,
};

const GFXglyph NotoSans_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 38, 12, 4, -38 },
  { 16, 9, 14, 17, 4, -38 },
  { 32, 32, 38, 34, 1, -38 },
  { 184, 22, 43, 30, 3, -40 },
  { 303, 36, 39, 42, 3, -38 },
  { 479, 32, 39, 37, 3, -38 },
  { 635, 1, 14, 9, 4, -38 },
  { 637, 10, 46, 14, 2, -38 },
  { 695, 9, 46, 14, 2, -38 },
  { 747, 23, 21, 29, 3, -40 },
  { 808, 24, 24, 30, 3, -31 },
  { 880, 5, 13, 10, 2, -6 },
  { 889, 13, 1, 17, 2, -15 },
  { 891, 3, 3, 12, 4, -3 },
  { 893, 15, 38, 17, 1, -38 },
  { 965, 24, 39, 30, 3, -38 },
  { 1082, 12, 38, 30, 5, -38 },
  { 1139, 23, 38, 30, 3, -38 },
  { 1249, 24, 39, 30, 2, -38 },
  { 1366, 29, 38, 30, 1, -38 },
  { 1504, 23, 39, 30, 4, -38 },
  { 1617, 23, 39, 30, 4, -38 },
  { 1730, 24, 38, 30, 3, -38 },
  { 1844, 24, 39, 30, 3, -38 },
  { 1961, 24, 39, 30, 3, -38 },
  { 2078, 3, 28, 12, 4, -28 },
  { 2089, 5, 35, 12, 2, -28 },
  { 2111, 24, 24, 30, 3, -31 },
  { 2183, 24, 12, 30, 3, -25 },
  { 2219, 24, 24, 30, 3, -31 },
  { 2291, 18, 38, 22, 2, -38 },
  { 2377, 41, 42, 47, 3, -37 },
  { 2593, 31, 38, 31, 0, -38 },
  { 2741, 25, 38, 32, 5, -38 },
  { 2860, 28, 39, 33, 3, -38 },
  { 2997, 28, 38, 37, 5, -38 },
  { 3130, 21, 38, 29, 5, -38 },
  { 3230, 21, 38, 26, 5, -38 },
  { 3330, 31, 39, 38, 3, -38 },
  { 3482, 27, 38, 37, 5, -38 },
  { 3611, 9, 38, 15, 3, -38 },
  { 3654, 12, 47, 12, -5, -38 },
  { 3725, 25, 38, 30, 5, -38 },
  { 3844, 21, 38, 27, 5, -38 },
  { 3944, 34, 38, 44, 5, -38 },
  { 4106, 26, 38, 37, 5, -38 },
  { 4230, 34, 39, 40, 3, -38 },
  { 4396, 22, 38, 30, 5, -38 },
  { 4501, 34, 47, 40, 3, -38 },
  { 4701, 24, 38, 31, 5, -38 },
  { 4815, 23, 39, 29, 3, -38 },
  { 4928, 27, 38, 27, 0, -38 },
  { 5057, 28, 39, 38, 5, -38 },
  { 5194, 30, 38, 30, 0, -38 },
  { 5337, 42, 38, 46, 2, -38 },
  { 5537, 27, 38, 27, 0, -38 },
  { 5666, 27, 38, 27, 0, -38 },
  { 5795, 27, 38, 31, 2, -38 },
  { 5924, 10, 46, 17, 5, -38 },
  { 5982, 15, 38, 17, 1, -38 },
  { 6054, 11, 46, 17, 1, -38 },
  { 6118, 26, 23, 30, 2, -38 },
  { 6193, 21, 1, 21, 0, 5 },
  { 6196, 9, 9, 13, 2, -41 },
  { 6207, 20, 29, 27, 3, -28 },
  { 6280, 23, 41, 31, 5, -40 },
  { 6398, 20, 30, 25, 3, -29 },
  { 6473, 23, 41, 31, 3, -40 },
  { 6591, 22, 30, 29, 3, -29 },
  { 6674, 17, 41, 15, 1, -41 },
  { 6762, 23, 42, 31, 3, -29 },
  { 6883, 21, 40, 30, 5, -40 },
  { 6988, 3, 38, 11, 4, -38 },
  { 7003, 10, 51, 11, -3, -38 },
  { 7067, 19, 40, 24, 5, -40 },
  { 7162, 1, 40, 11, 5, -40 },
  { 7167, 36, 29, 45, 5, -29 },
  { 7298, 21, 29, 30, 5, -29 },
  { 7375, 24, 30, 30, 3, -29 },
  { 7465, 23, 41, 31, 5, -29 },
  { 7583, 23, 41, 31, 3, -29 },
  { 7701, 14, 28, 20, 5, -28 },
  { 7750, 20, 30, 24, 2, -29 },
  { 7825, 14, 36, 17, 1, -35 },
  { 7888, 22, 29, 30, 4, -28 },
  { 7968, 23, 28, 23, 0, -28 },
  { 8049, 34, 28, 36, 1, -28 },
  { 8168, 23, 28, 25, 1, -28 },
  { 8249, 23, 41, 23, 0, -28 },
  { 8367, 20, 28, 24, 2, -28 },
  { 8437, 15, 46, 18, 1, -38 },
  { 8524, 2, 53, 28, 13, -40 },
  { 8538, 14, 46, 18, 2, -38 },
  { 8619, 24, 5, 30, 3, -21 },
};

const GFXfont NotoSans_Thin53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin53pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_THIN53PT7B_H_
