#ifndef _NOTOSANS_THIN45PT7B_H_
#define _NOTOSANS_THIN45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC1, 0xC1, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x10, 0x04, 0x00,
  0x02, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x40, 0x18, 0x00, 0x08, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x08,
  0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x40,
  0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00,
  0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x1E, 0x00, 0x3E, 0xFC, 0x30, 0x81, 0x98, 0x20, 0x04, 0x08, 0x02,
  0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0xC0,
  0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x62, 0x00, 0x06, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x02, 0x30, 0x00, 0x83, 0x00, 0x20, 0x60, 0x08, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x20, 0x20, 0x08, 0x1B, 0x02, 0x1C, 0x7F, 0xFC, 0x00, 0xB0,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x04, 0x02, 0x04, 0x00, 0x30, 0x10, 0x18, 0x00, 0x80, 0x40,
  0x20, 0x04, 0x03, 0x00, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x04,
  0x06, 0x00, 0x80, 0x10, 0x10, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x01, 0x02,
  0x00, 0x20, 0x04, 0x18, 0x00, 0x80, 0x10, 0x40, 0x02, 0x00, 0x42, 0x0F,
  0x08, 0x03, 0x08, 0xEE, 0x20, 0x08, 0x42, 0x04, 0xC0, 0x23, 0x10, 0x19,
  0x01, 0x88, 0x40, 0x22, 0x0C, 0x62, 0x00, 0xCF, 0xE1, 0x08, 0x01, 0x04,
  0x0C, 0x20, 0x04, 0x00, 0x20, 0x80, 0x10, 0x01, 0x02, 0x00, 0x40, 0x04,
  0x08, 0x01, 0x00, 0x20, 0x20, 0x04, 0x01, 0x80, 0x80, 0x10, 0x04, 0x02,
  0x00, 0x40, 0x30, 0x08, 0x03, 0x00, 0x80, 0x30, 0x08, 0x06, 0x00, 0x40,
  0x20, 0x10, 0x01, 0x01, 0x80, 0x80, 0x02, 0x0C, 0x06, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x80, 0x08, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x10, 0x00, 0x20, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x40, 0x60, 0x01, 0x10, 0x06, 0x00, 0x24, 0x00, 0x60, 0x0D, 0x80,
  0x06, 0x01, 0x20, 0x00, 0x60, 0x24, 0x00, 0x06, 0x08, 0x80, 0x00, 0x63,
  0x10, 0x00, 0x06, 0x42, 0x00, 0x00, 0x70, 0x40, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xE0, 0x80, 0x00, 0x66, 0x0C, 0x00, 0x18, 0x60, 0xC0, 0x0C, 0x06,
  0x07, 0xFE, 0x00, 0x60, 0xFE, 0xAA, 0xA8, 0x03, 0x06, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0xC0, 0x40,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40,
  0xC0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x20, 0x10, 0x1B, 0x82, 0x1E, 0x0E, 0x5C, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0x90, 0x00, 0x11, 0x00, 0x04, 0x30, 0x01, 0x03,
  0x00, 0x60, 0x20, 0x08, 0x02, 0x02, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x32, 0x22, 0x64, 0x44, 0xC8, 0x80, 0xFF, 0xE0, 0xF0, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x30, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00,
  0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x2C,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04,
  0x20, 0x00, 0x41, 0x00, 0x08, 0x18, 0x01, 0x00, 0xC0, 0x20, 0x03, 0xFC,
  0x00, 0x01, 0x81, 0xC1, 0xA3, 0x13, 0x0B, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0xE0, 0x18, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0xFF,
  0xE0, 0x38, 0x01, 0x8E, 0x00, 0x0C, 0x40, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x80,
  0x00, 0xCE, 0x00, 0x38, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x10, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x40, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xC1, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0xFF, 0xC0, 0x30, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC8, 0x00, 0x18, 0xE0, 0x07,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xBC, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x0F, 0x80, 0x87, 0xCF, 0x08, 0xC0, 0x18, 0x90, 0x00, 0x4A, 0x00, 0x06,
  0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x32, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x04, 0x18, 0x00, 0xC0, 0x60, 0x38, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x08, 0x20, 0x00, 0x46, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0x60,
  0x00, 0x42, 0x00, 0x08, 0x10, 0x01, 0x80, 0xC0, 0x70, 0x07, 0x0C, 0x00,
  0x1F, 0x00, 0x01, 0xB8, 0x00, 0x60, 0xE0, 0x18, 0x03, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0x44, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00,
  0x04, 0x30, 0x00, 0x81, 0x80, 0x30, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xF0, 0x03, 0x00, 0xC0, 0x20, 0x01, 0x02, 0x00, 0x04, 0x10, 0x00,
  0x31, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0xB0,
  0x00, 0x05, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x6C, 0x00, 0x06, 0x20, 0x00, 0x71, 0x80, 0x06, 0x86, 0x00, 0xE4, 0x0F,
  0xFC, 0x20, 0x06, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x33, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x22, 0x26, 0x44, 0x4C, 0x88,
  0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xC2, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x0F, 0x80, 0x08, 0x80, 0x0F, 0x1E, 0x01, 0x10, 0x03, 0x00,
  0x40, 0x36, 0x00, 0x80, 0x08, 0x02, 0x80, 0x30, 0x01, 0x00, 0x50, 0x04,
  0x00, 0x20, 0x0A, 0x01, 0x00, 0x0C, 0x01, 0xC0, 0x20, 0x01, 0x80, 0x38,
  0x04, 0x00, 0x30, 0x07, 0x00, 0x80, 0x04, 0x00, 0xE0, 0x10, 0x00, 0x80,
  0x1C, 0x02, 0x00, 0x10, 0x07, 0x80, 0x40, 0x02, 0x00, 0x90, 0x08, 0x00,
  0xE0, 0x12, 0x01, 0x80, 0x14, 0x06, 0x40, 0x10, 0x04, 0x80, 0x88, 0x01,
  0x83, 0x18, 0x61, 0x80, 0x1F, 0xC1, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x08,
  0x00, 0x10, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x60, 0x00, 0x80, 0x1F, 0xFF, 0xE0, 0x04, 0x00, 0x0C, 0x02,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x18, 0x10, 0x00, 0x02,
  0x04, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x08, 0x00, 0x70, 0x80, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x7E,
  0x0F, 0xFF, 0xE0, 0x80, 0x01, 0x88, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48,
  0x00, 0x18, 0x80, 0x0F, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0x00, 0x1E, 0x02,
  0x00, 0x07, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x40, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x44,
  0x00, 0x01, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x07, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xBF,
  0x80, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x70, 0x00, 0x04, 0x07,
  0x00, 0x0F, 0x00, 0x7F, 0xFE, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x7F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x48, 0x73, 0xF0, 0x80, 0x00, 0x78, 0x00, 0x04, 0x80, 0x00, 0x88,
  0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00,
  0x08, 0x60, 0x00, 0x8A, 0x00, 0x09, 0x10, 0x00, 0xA1, 0x80, 0x0C, 0x0C,
  0x00, 0x80, 0x40, 0x08, 0x06, 0x00, 0x80, 0x30, 0x08, 0x01, 0x00, 0x80,
  0x08, 0x08, 0x00, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x20, 0x80, 0x01, 0x08,
  0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x05, 0xA0, 0x00,
  0x00, 0xDB, 0x00, 0x00, 0x09, 0x90, 0x00, 0x01, 0x99, 0x80, 0x00, 0x11,
  0x88, 0x00, 0x01, 0x18, 0x80, 0x00, 0x31, 0x84, 0x00, 0x02, 0x18, 0x40,
  0x00, 0x61, 0x86, 0x00, 0x04, 0x18, 0x20, 0x00, 0x41, 0x82, 0x00, 0x08,
  0x18, 0x10, 0x00, 0x81, 0x81, 0x00, 0x18, 0x18, 0x18, 0x01, 0x01, 0x80,
  0x80, 0x10, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x06,
  0x01, 0x80, 0x60, 0x40, 0x18, 0x02, 0x0C, 0x01, 0x80, 0x30, 0x80, 0x18,
  0x01, 0x08, 0x01, 0x80, 0x11, 0x80, 0x18, 0x00, 0x90, 0x01, 0x80, 0x0B,
  0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0x40, 0x00, 0x18, 0x80, 0x00, 0x63, 0x00, 0x01, 0x84, 0x00,
  0x06, 0x08, 0x00, 0x18, 0x30, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80, 0x06,
  0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x86, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x20, 0x03, 0x88, 0x00, 0x32, 0x00, 0x06, 0x80, 0x00, 0xA0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x0C,
  0x80, 0x0C, 0x3F, 0xFC, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0xFF, 0xF8, 0x08, 0x00, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80,
  0x03, 0x08, 0x00, 0x60, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x80, 0x30, 0x08,
  0x01, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x60,
  0x80, 0x02, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x03, 0x00, 0x60, 0x00, 0xFF,
  0xF0, 0x60, 0x03, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x66, 0x00, 0x38,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x18, 0x06, 0x00, 0x60, 0x01, 0xFF, 0x80, 0xC0,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x08,
  0x18, 0x00, 0x04, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x80, 0x01,
  0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x03, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x30,
  0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x61, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x06, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x1A, 0x00, 0x03, 0x00, 0x00,
  0x90, 0x00, 0x14, 0x00, 0x04, 0xC0, 0x00, 0xA0, 0x00, 0x22, 0x00, 0x05,
  0x00, 0x02, 0x10, 0x00, 0x4C, 0x00, 0x10, 0xC0, 0x02, 0x20, 0x00, 0x82,
  0x00, 0x11, 0x00, 0x0C, 0x10, 0x00, 0x88, 0x00, 0x40, 0x80, 0x08, 0x20,
  0x02, 0x06, 0x00, 0x41, 0x00, 0x10, 0x10, 0x02, 0x08, 0x01, 0x80, 0x80,
  0x30, 0x60, 0x08, 0x04, 0x01, 0x01, 0x00, 0x40, 0x30, 0x08, 0x08, 0x06,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x04, 0x06, 0x03, 0x01, 0x00, 0x30, 0x20,
  0x08, 0x08, 0x00, 0x81, 0x00, 0x40, 0xC0, 0x04, 0x18, 0x03, 0x04, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x01, 0x84, 0x00, 0x43, 0x00, 0x04, 0x20, 0x02,
  0x10, 0x00, 0x23, 0x00, 0x18, 0x80, 0x01, 0x10, 0x00, 0x44, 0x00, 0x0C,
  0x80, 0x02, 0x60, 0x00, 0x24, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x50,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x80, 0x80, 0x02, 0x00, 0x80, 0x0C,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x02, 0x02, 0x00,
  0x02, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x10, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0x80,
  0x20, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x01,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x21,
  0x00, 0x00, 0xC1, 0x00, 0x01, 0x02, 0x00, 0x06, 0x02, 0x00, 0x08, 0x04,
  0x00, 0x30, 0x04, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x08, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x30, 0x40, 0x00, 0x20, 0x80, 0x00, 0x62,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFE, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x13, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x18, 0x00, 0x10, 0x20, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60,
  0x01, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x07, 0xF8, 0x0E, 0x03, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x3F, 0xF0, 0xE0, 0x09, 0x80, 0x05, 0x80, 0x02, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x34, 0x00, 0x2B, 0x00,
  0x34, 0xC0, 0x32, 0x3F, 0xE1, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x83, 0xFC, 0x08, 0xE0, 0x70, 0x98,
  0x01, 0x8B, 0x00, 0x0C, 0xA0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x4E, 0x00, 0x04, 0xA0, 0x00, 0x8B, 0x00,
  0x18, 0x98, 0x07, 0x08, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0x80, 0xC3, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x0F, 0xF0, 0x87,
  0x03, 0x11, 0x80, 0x12, 0x60, 0x01, 0x58, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00, 0x29, 0x80,
  0x0D, 0x18, 0x03, 0x20, 0xFF, 0x84, 0x03, 0xFC, 0x01, 0xC0, 0xC0, 0x60,
  0x0C, 0x18, 0x00, 0xC2, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x16, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x30, 0x3F, 0xF8, 0x00, 0xFE, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x03, 0xFF, 0xC0,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x21, 0xC0, 0xE4,
  0x60, 0x06, 0x90, 0x00, 0x56, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x32, 0x00, 0x0A, 0x60, 0x03, 0x47,
  0x00, 0xC8, 0x3F, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x60,
  0x01, 0x07, 0xC1, 0xC0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x3F, 0xC2, 0x30, 0x18, 0x90, 0x01,
  0x28, 0x00, 0x2E, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0xF0, 0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x9C, 0xF0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0xD0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0xC2, 0x00, 0xC1, 0x00,
  0xC0, 0x80, 0x40, 0x40, 0x40, 0x20, 0x40, 0x10, 0x40, 0x08, 0x60, 0x04,
  0x70, 0x02, 0x64, 0x01, 0x63, 0x00, 0xE0, 0xC0, 0x60, 0x20, 0x20, 0x08,
  0x10, 0x06, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x0C, 0x80,
  0x03, 0x40, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x87, 0xF0, 0x0F,
  0xE1, 0x18, 0x18, 0x60, 0x62, 0x40, 0x19, 0x80, 0x25, 0x00, 0x16, 0x00,
  0x2C, 0x00, 0x28, 0x00, 0x58, 0x00, 0x20, 0x00, 0xB0, 0x00, 0x40, 0x01,
  0xC0, 0x00, 0x80, 0x03, 0x80, 0x01, 0x00, 0x07, 0x00, 0x02, 0x00, 0x0E,
  0x00, 0x04, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x38, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x20, 0x00, 0xE0, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80,
  0x01, 0x00, 0x07, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x38, 0x00, 0x10, 0x00, 0x70, 0x00, 0x20, 0x00, 0xE0, 0x00,
  0x40, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x83, 0xFC, 0x23, 0x01, 0x89, 0x80,
  0x12, 0x80, 0x02, 0xA0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00,
  0x64, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x26,
  0x00, 0x06, 0x20, 0x00, 0xC1, 0x00, 0x08, 0x0C, 0x03, 0x00, 0x7F, 0xC0,
  0x83, 0xFC, 0x08, 0xE0, 0x70, 0x98, 0x01, 0x8B, 0x00, 0x0C, 0xA0, 0x00,
  0x4E, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6A,
  0x00, 0x04, 0xA0, 0x00, 0xC9, 0x00, 0x18, 0x8C, 0x03, 0x08, 0x7F, 0xC0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFC, 0x21, 0x80, 0xC4, 0x60, 0x04, 0x90, 0x00, 0x56, 0x00,
  0x0E, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00,
  0x76, 0x00, 0x0A, 0x60, 0x02, 0x46, 0x01, 0x88, 0x7F, 0xE1, 0x00, 0xC0,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x87, 0xF8,
  0xC0, 0x90, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xFC,
  0x0C, 0x03, 0x98, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x13, 0x00, 0x38, 0xFF,
  0xF0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x03, 0xFF,
  0xE1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x05, 0x40,
  0x03, 0x58, 0x01, 0x93, 0x00, 0xC4, 0x7F, 0xC1, 0x80, 0x00, 0x38, 0x00,
  0x05, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x00,
  0x20, 0x80, 0x0C, 0x10, 0x01, 0x01, 0x00, 0x20, 0x20, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x60, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x06, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x58, 0x01, 0x30,
  0x02, 0x40, 0x08, 0x80, 0x22, 0x00, 0x84, 0x01, 0x18, 0x04, 0x20, 0x08,
  0x40, 0x21, 0x80, 0x82, 0x03, 0x04, 0x04, 0x18, 0x10, 0x20, 0x20, 0x40,
  0x81, 0x02, 0x02, 0x04, 0x04, 0x10, 0x18, 0x60, 0x20, 0x80, 0x42, 0x01,
  0x08, 0x02, 0x10, 0x0C, 0x40, 0x18, 0x80, 0x22, 0x00, 0x4C, 0x01, 0x20,
  0x02, 0x40, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x50, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x40, 0x00, 0x6C, 0x00,
  0x18, 0xC0, 0x02, 0x08, 0x00, 0x80, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x01,
  0x00, 0x10, 0x60, 0x03, 0x18, 0x00, 0x32, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x60, 0x00, 0x44, 0x00, 0x18, 0x40, 0x06, 0x0C,
  0x00, 0x80, 0xC0, 0x20, 0x08, 0x0C, 0x00, 0x81, 0x00, 0x18, 0x40, 0x01,
  0x18, 0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0x20, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x00, 0x20, 0x80, 0x0C,
  0x10, 0x01, 0x01, 0x00, 0x20, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x60,
  0x08, 0x08, 0x01, 0x81, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x23, 0x00,
  0x04, 0x40, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x11,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x78, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x01, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x07, 0x01, 0x80, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0xF0, 0x00, 0x1E,
  0x00, 0x06, 0x1C, 0x01, 0x80, 0x70, 0x68, 0x00, 0xFC,
};

const GFXglyph NotoSans_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 32, 10, 4, -32 },
  { 9, 8, 11, 14, 3, -32 },
  { 20, 27, 32, 29, 1, -32 },
  { 128, 18, 37, 26, 3, -34 },
  { 212, 30, 33, 36, 3, -33 },
  { 336, 27, 33, 32, 3, -33 },
  { 448, 2, 11, 8, 3, -32 },
  { 451, 8, 39, 11, 2, -32 },
  { 490, 8, 39, 11, 2, -32 },
  { 529, 19, 18, 25, 3, -34 },
  { 572, 21, 20, 26, 2, -26 },
  { 625, 4, 11, 8, 2, -5 },
  { 631, 11, 1, 14, 2, -13 },
  { 633, 2, 2, 10, 4, -2 },
  { 634, 13, 32, 14, 1, -32 },
  { 686, 20, 33, 26, 3, -33 },
  { 769, 9, 32, 26, 5, -32 },
  { 805, 19, 33, 26, 3, -33 },
  { 884, 20, 33, 26, 2, -33 },
  { 967, 24, 32, 26, 1, -32 },
  { 1063, 20, 32, 26, 3, -32 },
  { 1143, 20, 33, 26, 3, -33 },
  { 1226, 20, 32, 26, 3, -32 },
  { 1306, 20, 33, 26, 3, -33 },
  { 1389, 21, 34, 26, 2, -33 },
  { 1479, 2, 24, 10, 4, -24 },
  { 1485, 4, 30, 10, 2, -24 },
  { 1500, 20, 20, 26, 3, -26 },
  { 1550, 21, 10, 26, 2, -21 },
  { 1577, 20, 20, 26, 3, -26 },
  { 1627, 15, 33, 19, 2, -33 },
  { 1689, 35, 37, 40, 2, -32 },
  { 1851, 26, 32, 26, 0, -32 },
  { 1955, 20, 32, 28, 5, -32 },
  { 2035, 23, 33, 28, 3, -33 },
  { 2130, 23, 32, 31, 5, -32 },
  { 2222, 17, 32, 25, 5, -32 },
  { 2290, 17, 32, 22, 5, -32 },
  { 2358, 26, 33, 32, 3, -33 },
  { 2466, 22, 32, 32, 5, -32 },
  { 2554, 7, 32, 13, 3, -32 },
  { 2582, 10, 40, 10, -4, -32 },
  { 2632, 20, 32, 25, 5, -32 },
  { 2712, 17, 32, 23, 5, -32 },
  { 2780, 28, 32, 38, 5, -32 },
  { 2892, 22, 32, 31, 5, -32 },
  { 2980, 28, 33, 34, 3, -33 },
  { 3096, 18, 32, 26, 5, -32 },
  { 3168, 28, 41, 34, 3, -33 },
  { 3312, 20, 32, 26, 5, -32 },
  { 3392, 19, 33, 24, 3, -33 },
  { 3471, 23, 32, 23, 0, -32 },
  { 3563, 24, 32, 32, 4, -32 },
  { 3659, 25, 32, 25, 0, -32 },
  { 3759, 37, 32, 39, 1, -32 },
  { 3907, 23, 32, 23, 0, -32 },
  { 3999, 23, 32, 23, 0, -32 },
  { 4091, 22, 32, 26, 2, -32 },
  { 4179, 9, 39, 14, 4, -32 },
  { 4223, 13, 32, 14, 1, -32 },
  { 4275, 9, 39, 14, 1, -32 },
  { 4319, 22, 19, 26, 2, -32 },
  { 4372, 18, 1, 18, 0, 4 },
  { 4375, 7, 7, 11, 2, -34 },
  { 4382, 17, 24, 23, 2, -24 },
  { 4433, 20, 34, 26, 4, -34 },
  { 4518, 17, 24, 21, 3, -24 },
  { 4569, 19, 34, 26, 3, -34 },
  { 4650, 19, 24, 24, 3, -24 },
  { 4707, 15, 34, 12, 0, -34 },
  { 4771, 19, 35, 26, 3, -24 },
  { 4855, 18, 34, 26, 4, -34 },
  { 4932, 2, 32, 9, 4, -32 },
  { 4940, 8, 43, 9, -2, -32 },
  { 4983, 17, 34, 20, 4, -34 },
  { 5056, 1, 34, 9, 4, -34 },
  { 5061, 31, 24, 38, 4, -24 },
  { 5154, 18, 24, 26, 4, -24 },
  { 5208, 20, 24, 26, 3, -24 },
  { 5268, 20, 34, 26, 4, -24 },
  { 5353, 19, 34, 26, 3, -24 },
  { 5434, 12, 24, 17, 4, -24 },
  { 5470, 17, 24, 21, 2, -24 },
  { 5521, 13, 30, 14, 0, -30 },
  { 5570, 18, 24, 26, 4, -24 },
  { 5624, 19, 24, 19, 0, -24 },
  { 5681, 29, 24, 31, 1, -24 },
  { 5768, 19, 24, 22, 1, -24 },
  { 5825, 19, 35, 19, 0, -24 },
  { 5909, 17, 24, 21, 2, -24 },
  { 5960, 13, 39, 15, 1, -32 },
  { 6024, 2, 45, 24, 11, -34 },
  { 6036, 12, 39, 15, 2, -32 },
  { 6095, 20, 4, 26, 3, -18 },
};

const GFXfont NotoSans_Thin45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin45pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_THIN45PT7B_H_
