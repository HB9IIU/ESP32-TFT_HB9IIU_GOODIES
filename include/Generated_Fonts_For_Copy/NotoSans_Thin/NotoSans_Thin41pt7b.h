#ifndef _NOTOSANS_THIN41PT7B_H_
#define _NOTOSANS_THIN41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0x3E,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x10, 0x00, 0x40, 0x10, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20,
  0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x80, 0x20, 0x00, 0x80, 0x40,
  0x3F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xFE, 0x02, 0x01, 0x00,
  0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x04, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x19, 0x1E, 0x61, 0x02, 0x41, 0x00,
  0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x19, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x30,
  0x01, 0x0C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x01, 0x02, 0x81, 0x0C, 0xFF, 0x78,
  0x03, 0x80, 0x01, 0x00, 0x01, 0x00, 0x07, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x60, 0x20, 0x40, 0x04, 0x06, 0x06, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x03, 0x02, 0x00, 0xC0, 0x10,
  0x60, 0x0C, 0x01, 0x04, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03, 0x08, 0x00,
  0x40, 0x21, 0x0F, 0x84, 0x02, 0x11, 0x8C, 0x40, 0x22, 0x30, 0x66, 0x06,
  0x22, 0x02, 0x20, 0x44, 0x60, 0x31, 0x98, 0x44, 0x01, 0x0E, 0x08, 0x40,
  0x10, 0x01, 0x84, 0x01, 0x00, 0x10, 0x40, 0x10, 0x02, 0x04, 0x01, 0x00,
  0x20, 0x40, 0x10, 0x04, 0x04, 0x01, 0x00, 0x40, 0x40, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x20, 0x10, 0x02, 0x02, 0x03, 0x00, 0x10, 0x40,
  0x20, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x18, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x18, 0x00, 0x02, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x20, 0x01, 0x60, 0x10, 0x02, 0x40, 0x08, 0x02,
  0x80, 0x04, 0x02, 0x80, 0x02, 0x04, 0x80, 0x01, 0x04, 0x80, 0x00, 0x88,
  0x80, 0x00, 0x58, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x48,
  0x60, 0x01, 0x84, 0x30, 0x07, 0x06, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x06,
  0x18, 0x20, 0x81, 0x04, 0x08, 0x30, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x18, 0x18, 0xC0, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0x82, 0x0E, 0x79, 0x38, 0x03, 0xE0,
  0x00, 0xC0, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x40, 0x80, 0x60,
  0x20, 0x20, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x25, 0xB4, 0x94, 0x90, 0xFF, 0xC0, 0x7C, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xCE, 0x01, 0x80, 0x40, 0xC0,
  0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01,
  0x10, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x08, 0x18, 0x0C, 0x01, 0xFE, 0x00,
  0x01, 0x81, 0x43, 0x23, 0x12, 0x0E, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x01, 0xE0, 0x03,
  0x8E, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xCF, 0x07, 0x00, 0x23,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0xC0, 0x06, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00,
  0x41, 0x00, 0x02, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x02, 0x01,
  0x00, 0x10, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x01, 0x00,
  0x80, 0x04, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xF8, 0x10, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x48, 0x00, 0x23, 0x00, 0x30,
  0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x40, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x83, 0xF8, 0x23, 0x01, 0x89, 0x00,
  0x32, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x98,
  0x00, 0x22, 0x00, 0x18, 0x40, 0x04, 0x08, 0x06, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x03, 0x8F,
  0x03, 0x00, 0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x64, 0x00, 0x09,
  0x00, 0x06, 0x40, 0x01, 0x10, 0x00, 0x46, 0x00, 0x30, 0xC0, 0x18, 0x1C,
  0x08, 0x01, 0xDC, 0x00, 0x1C, 0x00, 0x18, 0xE0, 0x18, 0x0C, 0x08, 0x00,
  0xC4, 0x00, 0x13, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x0C, 0x30,
  0x06, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x01, 0xC7, 0x80, 0x60, 0x18, 0x10,
  0x01, 0x86, 0x00, 0x18, 0x80, 0x01, 0x10, 0x00, 0x26, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0xD0, 0x00, 0x31, 0x00, 0x0A, 0x10, 0x02, 0x41, 0xC3, 0x88, 0x07,
  0x81, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x7F, 0xC0, 0x00, 0x5D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x27, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x26, 0x64,
  0x44, 0x88, 0x80, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x1E, 0x07, 0x8E, 0x20, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x04,
  0x20, 0x01, 0xF0, 0x02, 0x20, 0x06, 0x0E, 0x02, 0x40, 0x18, 0x04, 0x02,
  0x40, 0x30, 0x04, 0x03, 0x40, 0x20, 0x04, 0x01, 0xC0, 0x40, 0x04, 0x01,
  0x80, 0x40, 0x04, 0x01, 0x80, 0x40, 0x04, 0x01, 0x80, 0x40, 0x04, 0x01,
  0x80, 0x40, 0x04, 0x01, 0x80, 0x40, 0x04, 0x02, 0x80, 0x40, 0x04, 0x02,
  0x80, 0x40, 0x0C, 0x02, 0xC0, 0x60, 0x1C, 0x04, 0x40, 0x20, 0x12, 0x0C,
  0x40, 0x1D, 0xE3, 0xB8, 0x60, 0x03, 0x00, 0x40, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x01,
  0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x04, 0x00, 0x20, 0x07, 0xFF, 0xE0, 0x08, 0x00,
  0x30, 0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x10, 0x00, 0xE2,
  0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x88,
  0x00, 0x61, 0xFF, 0xF0, 0x20, 0x03, 0x84, 0x00, 0x0C, 0x80, 0x00, 0xD0,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x06, 0x40,
  0x03, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0xC0, 0x02,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x02, 0x00, 0x1C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x22, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x03, 0x08, 0x00,
  0x30, 0x20, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0xF8, 0x0C, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x04, 0x60, 0x00, 0x08, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x60, 0x1F, 0xFF, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xA0, 0xDF, 0x80, 0x80, 0x00, 0xF0, 0x00, 0x32, 0x00,
  0x0C, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x30, 0x20, 0x0C, 0x04, 0x03,
  0x00, 0x80, 0xC0, 0x10, 0x30, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x08, 0xE0,
  0x01, 0x36, 0x00, 0x2C, 0x40, 0x07, 0x04, 0x00, 0xC0, 0xC0, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x01, 0x81, 0x00, 0x10, 0x20, 0x01,
  0x04, 0x00, 0x30, 0x80, 0x03, 0x10, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x16, 0x80,
  0x00, 0x05, 0x90, 0x00, 0x03, 0x64, 0x00, 0x00, 0x98, 0x80, 0x00, 0x26,
  0x20, 0x00, 0x11, 0x8C, 0x00, 0x04, 0x61, 0x00, 0x03, 0x18, 0x40, 0x00,
  0x86, 0x08, 0x00, 0x21, 0x82, 0x00, 0x10, 0x60, 0xC0, 0x04, 0x18, 0x10,
  0x03, 0x06, 0x04, 0x00, 0x81, 0x80, 0x80, 0x20, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x06, 0x01, 0x02, 0x01, 0x80, 0x40, 0x80, 0x60, 0x08, 0x60,
  0x18, 0x02, 0x10, 0x06, 0x00, 0xC4, 0x01, 0x80, 0x12, 0x00, 0x60, 0x04,
  0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x40,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x1B, 0x00, 0x01, 0x90, 0x00,
  0x18, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x00, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80,
  0x20, 0x18, 0x03, 0x01, 0x80, 0x10, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x18,
  0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x09,
  0x80, 0x00, 0x58, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x01, 0x80, 0x0C, 0x01, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x02, 0x20, 0x00, 0x02, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x40, 0x06, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x14, 0x00, 0x12, 0x00, 0x31, 0xFF, 0xF0, 0xFE, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x01, 0x80, 0x0C, 0x01, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x02, 0x20, 0x00, 0x02, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x10,
  0x01, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x88, 0x00, 0x31, 0x00, 0x0C, 0x20, 0x0E, 0x07, 0xFF, 0x00, 0x80,
  0x20, 0x10, 0x06, 0x02, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0xC1, 0x00,
  0x08, 0x20, 0x01, 0x84, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x32, 0x00,
  0x02, 0x40, 0x00, 0x68, 0x00, 0x06, 0x00, 0xF0, 0x03, 0xC3, 0xE1, 0x80,
  0x08, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0xC0, 0x06, 0x1F,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00,
  0x11, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0x00,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x13, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x84, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00, 0x40, 0x02, 0x00,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x50, 0x00,
  0x68, 0x00, 0x28, 0x00, 0x22, 0x00, 0x12, 0x00, 0x11, 0x00, 0x09, 0x00,
  0x08, 0x80, 0x08, 0x80, 0x0C, 0x60, 0x04, 0x40, 0x04, 0x10, 0x02, 0x10,
  0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x01, 0x04, 0x01, 0x01, 0x00, 0x83,
  0x00, 0x80, 0x80, 0x40, 0x80, 0x40, 0x40, 0x60, 0x40, 0x60, 0x20, 0x20,
  0x20, 0x20, 0x08, 0x10, 0x08, 0x10, 0x04, 0x08, 0x04, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x01, 0x84, 0x01, 0x84, 0x00, 0x42, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x23, 0x00, 0x11, 0x00, 0x11, 0x00, 0x04, 0x80, 0x0C, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x60, 0x01, 0x60, 0x00, 0xA0, 0x00, 0xA0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x31, 0x00, 0x01, 0x04, 0x00, 0x10, 0x30, 0x00, 0x80, 0x80,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x40, 0x40, 0x03, 0x06, 0x00,
  0x08, 0x20, 0x00, 0x22, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x60, 0x00,
  0x41, 0x00, 0x04, 0x04, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80, 0x20, 0x02,
  0x03, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x28, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x88, 0x00,
  0x08, 0x40, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x60, 0x20, 0x02, 0x01,
  0x00, 0x30, 0x04, 0x01, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80, 0x06, 0x08,
  0x00, 0x10, 0x40, 0x00, 0xC4, 0x00, 0x02, 0x20, 0x00, 0x0A, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0xFF, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00,
  0x81, 0x00, 0x20, 0x20, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x12, 0x00, 0x02, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0x07, 0xF0, 0x38, 0x1C, 0x20, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xFF, 0x1C, 0x03,
  0x30, 0x03, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x05, 0x40, 0x09, 0x60, 0x11, 0x1F, 0xE1, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x43, 0xF8, 0x27, 0x03, 0x16, 0x00, 0x4A, 0x00, 0x36,
  0x00, 0x0B, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x6A, 0x00, 0x24, 0x80, 0x62,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0x01, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x03, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0xFE, 0x10, 0xE0, 0x64, 0x60,
  0x0D, 0x30, 0x01, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x36, 0x00, 0x0C, 0x80,
  0x03, 0x10, 0x01, 0x46, 0x00, 0x90, 0x7F, 0xC4, 0x03, 0xF8, 0x01, 0x83,
  0x81, 0x80, 0x20, 0x40, 0x04, 0x20, 0x01, 0x88, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x00, 0xD0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x81, 0xFF, 0xC0, 0x01, 0xFC,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x03, 0xFF, 0x80, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x03, 0xF8, 0x43, 0x81, 0x91, 0x80, 0x14,
  0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xD8, 0x00, 0x32, 0x00, 0x1C,
  0x40, 0x05, 0x0C, 0x06, 0x41, 0xFF, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x88, 0x00,
  0xC3, 0xC0, 0xE0, 0x0F, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87,
  0xF0, 0x98, 0x0C, 0xB0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x7C, 0x00, 0x55, 0x55, 0x55,
  0x55, 0x55, 0x50, 0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60,
  0xA3, 0x78, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x1A, 0x00, 0x24, 0x00,
  0x88, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x83, 0x01, 0x0C, 0x02,
  0x30, 0x04, 0x60, 0x09, 0x20, 0x14, 0x60, 0x30, 0x40, 0x40, 0x40, 0x80,
  0x41, 0x00, 0xC2, 0x00, 0x84, 0x00, 0x88, 0x00, 0x90, 0x01, 0xA0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x87, 0xE0, 0x3F, 0x09, 0x83, 0x0C, 0x0C,
  0xA0, 0x09, 0x00, 0x4C, 0x00, 0xA0, 0x02, 0xC0, 0x06, 0x00, 0x28, 0x00,
  0x60, 0x02, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00,
  0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80,
  0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38,
  0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x87, 0xF0,
  0x98, 0x0C, 0xB0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x01, 0xFC, 0x00, 0xC0, 0xC0, 0x60,
  0x04, 0x08, 0x00, 0x42, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x1A, 0x00,
  0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x44, 0x00,
  0x08, 0xC0, 0x02, 0x08, 0x00, 0xC0, 0xC0, 0x30, 0x0F, 0xF8, 0x00, 0x83,
  0xF0, 0x23, 0x03, 0x09, 0x00, 0x22, 0x80, 0x04, 0xC0, 0x01, 0x30, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x4E, 0x00, 0x32, 0x80, 0x08, 0x98, 0x0C, 0x23, 0xFE,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF8, 0x43, 0x81, 0x91, 0x80, 0x34, 0xC0, 0x05, 0x20, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0xD8, 0x00, 0x32, 0x00, 0x14, 0xC0, 0x0D, 0x18, 0x06, 0x41, 0xFE,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x87,
  0xF3, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x60, 0x19, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x28, 0x01, 0x8F, 0xFE, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x07, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0xA4, 0x00, 0x93,
  0x00, 0x88, 0x7F, 0x84, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x40, 0x08, 0x10, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x61, 0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00,
  0x18, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x26, 0x01, 0x10, 0x08, 0x80, 0x44, 0x06, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x42,
  0x06, 0x10, 0x10, 0x80, 0x88, 0x04, 0x20, 0x22, 0x00, 0x90, 0x08, 0x80,
  0x24, 0x01, 0x40, 0x09, 0x00, 0x50, 0x01, 0x40, 0x14, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x88, 0x00,
  0x82, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x40, 0x10, 0x60, 0x04, 0x20, 0x03,
  0x20, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x16, 0x00, 0x11, 0x00,
  0x18, 0x40, 0x08, 0x30, 0x08, 0x08, 0x0C, 0x02, 0x04, 0x00, 0x84, 0x00,
  0x64, 0x00, 0x16, 0x00, 0x04, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x04, 0x08, 0x01, 0x06,
  0x00, 0x61, 0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x05, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x08, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xE0, 0x60, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x1C, 0x00,
  0xC0, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x07, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x3F,
  0x80, 0x38, 0x0C, 0x0E, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 7, 10, 13, 3, -29 },
  { 21, 24, 29, 26, 1, -29 },
  { 108, 16, 33, 23, 3, -31 },
  { 174, 28, 30, 33, 2, -30 },
  { 279, 24, 30, 29, 3, -30 },
  { 369, 1, 10, 7, 3, -29 },
  { 371, 7, 35, 10, 2, -29 },
  { 402, 8, 35, 10, 1, -29 },
  { 437, 17, 16, 23, 3, -31 },
  { 471, 19, 19, 23, 2, -24 },
  { 517, 3, 10, 8, 2, -5 },
  { 521, 10, 1, 13, 2, -12 },
  { 523, 3, 2, 9, 3, -2 },
  { 524, 12, 29, 13, 1, -29 },
  { 568, 18, 30, 23, 3, -30 },
  { 636, 9, 29, 23, 4, -29 },
  { 669, 18, 30, 23, 2, -30 },
  { 737, 18, 30, 23, 2, -30 },
  { 805, 22, 29, 23, 1, -29 },
  { 885, 18, 29, 23, 3, -29 },
  { 951, 18, 30, 23, 3, -30 },
  { 1019, 19, 29, 23, 2, -29 },
  { 1088, 18, 30, 23, 3, -30 },
  { 1156, 19, 30, 23, 2, -30 },
  { 1228, 3, 22, 9, 3, -22 },
  { 1237, 4, 27, 9, 2, -22 },
  { 1251, 19, 18, 23, 2, -24 },
  { 1294, 19, 9, 23, 2, -19 },
  { 1316, 19, 18, 23, 2, -24 },
  { 1359, 13, 30, 17, 2, -30 },
  { 1408, 32, 33, 36, 2, -29 },
  { 1540, 24, 29, 24, 0, -29 },
  { 1627, 19, 29, 25, 4, -29 },
  { 1696, 21, 30, 25, 3, -30 },
  { 1775, 22, 29, 28, 4, -29 },
  { 1855, 16, 29, 23, 4, -29 },
  { 1913, 16, 29, 20, 4, -29 },
  { 1971, 23, 30, 30, 3, -30 },
  { 2058, 21, 29, 29, 4, -29 },
  { 2135, 7, 29, 12, 2, -29 },
  { 2161, 9, 36, 9, -4, -29 },
  { 2202, 19, 29, 23, 4, -29 },
  { 2271, 16, 29, 21, 4, -29 },
  { 2329, 26, 29, 34, 4, -29 },
  { 2424, 20, 29, 29, 4, -29 },
  { 2497, 25, 30, 31, 3, -30 },
  { 2591, 17, 29, 24, 4, -29 },
  { 2653, 25, 37, 31, 3, -30 },
  { 2769, 19, 29, 24, 4, -29 },
  { 2838, 18, 30, 22, 2, -30 },
  { 2906, 21, 29, 21, 0, -29 },
  { 2983, 21, 29, 29, 4, -29 },
  { 3060, 23, 29, 23, 0, -29 },
  { 3144, 33, 29, 36, 1, -29 },
  { 3264, 21, 29, 21, 0, -29 },
  { 3341, 21, 29, 21, 0, -29 },
  { 3418, 21, 29, 24, 1, -29 },
  { 3495, 8, 35, 13, 4, -29 },
  { 3530, 12, 29, 13, 1, -29 },
  { 3574, 8, 35, 13, 1, -29 },
  { 3609, 19, 18, 23, 2, -29 },
  { 3652, 16, 1, 16, 0, 4 },
  { 3654, 7, 6, 10, 2, -31 },
  { 3660, 16, 22, 21, 2, -22 },
  { 3704, 17, 31, 24, 4, -31 },
  { 3770, 16, 22, 19, 2, -22 },
  { 3814, 18, 31, 24, 2, -31 },
  { 3884, 18, 22, 22, 2, -22 },
  { 3934, 14, 31, 11, 0, -31 },
  { 3989, 18, 32, 24, 2, -22 },
  { 4061, 16, 31, 24, 4, -31 },
  { 4123, 2, 30, 8, 3, -30 },
  { 4131, 7, 40, 8, -2, -30 },
  { 4166, 15, 31, 19, 4, -31 },
  { 4225, 1, 31, 8, 4, -31 },
  { 4229, 28, 22, 35, 4, -22 },
  { 4306, 16, 22, 24, 4, -22 },
  { 4350, 19, 22, 24, 2, -22 },
  { 4403, 18, 32, 24, 4, -22 },
  { 4475, 18, 32, 24, 2, -22 },
  { 4547, 11, 22, 15, 4, -22 },
  { 4578, 15, 22, 19, 2, -22 },
  { 4620, 12, 27, 13, 0, -27 },
  { 4661, 17, 22, 24, 3, -22 },
  { 4708, 18, 22, 18, 0, -22 },
  { 4758, 26, 22, 28, 1, -22 },
  { 4830, 17, 22, 20, 1, -22 },
  { 4877, 18, 32, 18, 0, -22 },
  { 4949, 15, 22, 19, 2, -22 },
  { 4991, 11, 35, 14, 1, -29 },
  { 5040, 1, 41, 22, 10, -31 },
  { 5046, 12, 35, 14, 1, -29 },
  { 5099, 19, 3, 23, 2, -16 },
};

const GFXfont NotoSans_Thin41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin41pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_THIN41PT7B_H_
