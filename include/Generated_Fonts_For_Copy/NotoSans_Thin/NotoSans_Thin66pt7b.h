#ifndef _NOTOSANS_THIN66PT7B_H_
#define _NOTOSANS_THIN66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xC9, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x20, 0x00, 0x00, 0x2F, 0xFA, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0x88, 0xFE, 0x03, 0x81, 0x00, 0xE0, 0xC0, 0x20, 0x04,
  0x30, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x10, 0x00, 0x20, 0x02,
  0x00, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x30, 0x01, 0x00, 0x06,
  0x00, 0x20, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x10,
  0x00, 0x38, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x38, 0x08, 0x00, 0x03,
  0x81, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x47, 0x80, 0x00,
  0x08, 0x3C, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x20, 0x1C, 0x00, 0x04, 0x01,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00,
  0x40, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x20, 0x03,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x10, 0x03, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x08, 0x0E, 0x3C, 0x01, 0x03, 0x83,
  0xFC, 0x27, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x00, 0x0C, 0x0C,
  0x07, 0xC0, 0xC0, 0x00, 0xC1, 0x81, 0xFF, 0x0C, 0x00, 0x08, 0x18, 0x30,
  0x18, 0x60, 0x01, 0x83, 0x06, 0x00, 0xC6, 0x00, 0x18, 0x30, 0xC0, 0x06,
  0x60, 0x03, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x30, 0x61, 0x80, 0x02, 0x38,
  0x06, 0x0C, 0x18, 0x00, 0x31, 0xC0, 0xC0, 0x81, 0x80, 0x03, 0x0F, 0xF8,
  0x18, 0x18, 0x00, 0x30, 0x1E, 0x03, 0x01, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x00, 0x03, 0x83, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x19,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x80, 0x18, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x00, 0x60,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x60, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x0E, 0xC0,
  0x30, 0x00, 0x00, 0x1C, 0x60, 0x38, 0x00, 0x00, 0x38, 0x70, 0x1C, 0x00,
  0x00, 0x60, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xAA, 0x80, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x60, 0x02, 0xF8, 0x06, 0x01, 0xF3, 0xF0,
  0x60, 0xF8, 0x03, 0xC6, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x98,
  0xC6, 0x33, 0x18, 0xC4, 0x63, 0x10, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x5F,
  0xF4, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x33, 0x03, 0x8C,
  0x1C, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x03,
  0xC1, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x88, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xE0,
  0x02, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x03, 0xFC, 0x00, 0x60, 0x7F, 0xFE, 0x01, 0x07, 0x80, 0x1E,
  0x04, 0x38, 0x00, 0x1C, 0x11, 0x80, 0x00, 0x18, 0x4C, 0x00, 0x00, 0x63,
  0x60, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x00,
  0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01,
  0xEC, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x01, 0xD8, 0xC0, 0x00, 0x1C, 0xC3,
  0x00, 0x01, 0xC6, 0x0F, 0x00, 0x78, 0x30, 0x1F, 0xFF, 0x01, 0x80, 0x1F,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF,
  0xA0, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x61,
  0x8E, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x08, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0x00,
  0x3C, 0x30, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5A,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xC1, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x63, 0x00,
  0x03, 0x80, 0x01, 0x00, 0x06, 0x30, 0x00, 0x70, 0x00, 0x10, 0x00, 0x66,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x26, 0x00, 0x18, 0x00, 0x03, 0x00, 0x02, 0x60, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x26, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x02, 0xC0, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x2C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x02, 0xC0, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x64, 0x00, 0x30, 0x00, 0x07, 0x00, 0x06,
  0x40, 0x03, 0x00, 0x00, 0x70, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x0C, 0x60, 0x01, 0x80, 0x00, 0xD0, 0x00, 0x86, 0x00, 0x0C, 0x00, 0x19,
  0x80, 0x18, 0x60, 0x00, 0xE0, 0x03, 0x18, 0x03, 0x02, 0x00, 0x07, 0x00,
  0xE0, 0xC0, 0x60, 0x30, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x03, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x20, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x07,
  0xC0, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1E, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x08, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1C, 0x3F, 0xF8, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0xC1, 0xE1, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x03, 0x1D, 0x80, 0x00, 0x0C, 0xE3,
  0x00, 0x00, 0x37, 0x0E, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xEC, 0x00,
  0x00, 0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xDD, 0x00, 0x00, 0x00,
  0x00, 0x6E, 0xC0, 0x00, 0x00, 0x00, 0x67, 0x60, 0x00, 0x00, 0x00, 0x33,
  0x98, 0x00, 0x00, 0x00, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x18, 0xE2, 0x00,
  0x00, 0x00, 0x0C, 0x71, 0x80, 0x00, 0x00, 0x0C, 0x38, 0xC0, 0x00, 0x00,
  0x06, 0x1C, 0x30, 0x00, 0x00, 0x02, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x07,
  0x06, 0x00, 0x00, 0x01, 0x83, 0x83, 0x00, 0x00, 0x01, 0x81, 0xC1, 0x80,
  0x00, 0x00, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x40, 0x70, 0x30, 0x00, 0x00,
  0x60, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x06, 0x00, 0x00, 0x30, 0x0E,
  0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x04, 0x00, 0xE0, 0x0C, 0x00, 0x06,
  0x00, 0x70, 0x02, 0x00, 0x03, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x00, 0x60, 0x10, 0x00, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x70,
  0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x18, 0x00,
  0x03, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x03, 0xC0, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x18,
  0x03, 0xC0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01,
  0x83, 0xC0, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00,
  0x63, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x78, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x07, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xF0,
  0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3D, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00,
  0x60, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x03,
  0xF0, 0x3C, 0x07, 0x80, 0x03, 0x81, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0x80, 0xFE, 0x00, 0x41, 0xE0, 0x00, 0x23, 0x80, 0x00, 0x13, 0x80,
  0x00, 0x09, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x2B, 0x00, 0x00, 0x35, 0x80, 0x00, 0x32, 0xE0, 0x00, 0x31,
  0x38, 0x00, 0x30, 0x8F, 0x00, 0xF0, 0x41, 0xFF, 0xE0, 0x20, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x0F, 0xFE, 0x00, 0xC1,
  0xE0, 0x3C, 0x06, 0x38, 0x00, 0x38, 0x33, 0x80, 0x00, 0xE1, 0xB8, 0x00,
  0x03, 0x0D, 0x80, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x32, 0xC0, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x27, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x19, 0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x0C, 0x6C, 0x00, 0x00, 0xC2,
  0x30, 0x00, 0x0C, 0x10, 0xC0, 0x01, 0xC0, 0x83, 0xC0, 0x3C, 0x04, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x3E, 0x01, 0xE0, 0x38, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x40, 0x7C, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x60, 0x0F, 0xFF, 0x03,
  0x01, 0xF0, 0x3C, 0x18, 0x1C, 0x00, 0x38, 0xC1, 0x80, 0x00, 0xE6, 0x18,
  0x00, 0x03, 0x31, 0x80, 0x00, 0x0D, 0x98, 0x00, 0x00, 0x2C, 0xC0, 0x00,
  0x01, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0xD0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x1E, 0x60, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x0D, 0x8C, 0x00, 0x00,
  0xCC, 0x30, 0x00, 0x06, 0x60, 0xE0, 0x00, 0xE3, 0x03, 0xC0, 0x1C, 0x18,
  0x07, 0xFF, 0xC0, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xC0, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0x81,
  0x01, 0xF0, 0x3E, 0x10, 0x38, 0x00, 0x71, 0x06, 0x00, 0x01, 0x90, 0xC0,
  0x00, 0x0D, 0x18, 0x00, 0x00, 0xD3, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x05, 0x38, 0x00, 0x00, 0xD1, 0x80, 0x00, 0x19, 0x0C, 0x00, 0x03,
  0x90, 0x70, 0x00, 0x71, 0x03, 0xC0, 0x3C, 0x10, 0x0F, 0xFF, 0x01, 0x00,
  0x0F, 0x80, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0xF0, 0x01, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x03, 0xFF, 0xC0, 0xC3,
  0xE0, 0x7C, 0x31, 0xC0, 0x03, 0x8C, 0xC0, 0x00, 0x33, 0x60, 0x00, 0x0E,
  0xD0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x10, 0x6E, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x60, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC8, 0x38, 0xFF,
  0x07, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC3,
  0xC0, 0x00, 0xC6, 0x60, 0x00, 0xCC, 0x30, 0x00, 0xD8, 0x18, 0x00, 0xD8,
  0x18, 0x00, 0xF0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x04, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x20, 0xF0, 0x38, 0x07,
  0x81, 0xE1, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x88, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20,
  0x3F, 0xFC, 0x08, 0x1E, 0x07, 0xC2, 0x1C, 0x00, 0x38, 0x8C, 0x00, 0x03,
  0x26, 0x00, 0x00, 0xED, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x02, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x04, 0x03, 0xFF, 0x80, 0x20, 0x7C, 0x0F, 0x01, 0x07,
  0x00, 0x0E, 0x0C, 0x60, 0x00, 0x38, 0x66, 0x00, 0x00, 0xE3, 0x60, 0x00,
  0x03, 0x1A, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01,
  0x38, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00,
  0x63, 0x60, 0x00, 0x03, 0x1B, 0x00, 0x00, 0x30, 0xCC, 0x00, 0x03, 0x06,
  0x38, 0x00, 0x70, 0x30, 0xF0, 0x0F, 0x01, 0x81, 0xFF, 0xE0, 0x0C, 0x00,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x01,
  0x01, 0xE0, 0x3C, 0x10, 0x70, 0x00, 0x61, 0x0E, 0x00, 0x03, 0x10, 0xC0,
  0x00, 0x19, 0x18, 0x00, 0x00, 0xD3, 0x00, 0x00, 0x05, 0x30, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x0D, 0x30, 0x00, 0x00, 0xD1, 0x80, 0x00, 0x19, 0x0C, 0x00, 0x03,
  0x10, 0x60, 0x00, 0xE1, 0x03, 0xC0, 0x3C, 0x10, 0x1F, 0xFF, 0x01, 0x00,
  0x1F, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0xC0, 0xFF, 0xF0, 0xF0, 0x6C, 0xE0, 0x03, 0x30,
  0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x7E, 0x1C, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xFC, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x04, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1D,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1E, 0x40, 0x00,
  0x06, 0xCC, 0x00, 0x00, 0x98, 0xC0, 0x00, 0x73, 0x0C, 0x00, 0x1C, 0x60,
  0xF0, 0x1E, 0x0C, 0x0F, 0xFF, 0x81, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x02,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0xC0, 0x01, 0x80, 0x08, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x26, 0x00,
  0x00, 0xD0, 0x00, 0x0C, 0x40, 0x00, 0x13, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x21, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x04,
  0x0C, 0x00, 0x10, 0x30, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x10, 0x08, 0x00, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x10, 0x01, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x30, 0x10, 0x00, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x40, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x02, 0x10, 0x00,
  0x08, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0,
  0x07, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x04, 0xF1, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x78, 0x1E, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 48, 15, 6, -47 },
  { 19, 11, 17, 21, 5, -47 },
  { 43, 39, 47, 43, 2, -47 },
  { 273, 27, 54, 38, 4, -50 },
  { 456, 44, 49, 52, 4, -48 },
  { 726, 40, 49, 46, 4, -48 },
  { 971, 2, 17, 11, 5, -47 },
  { 976, 12, 57, 17, 3, -47 },
  { 1062, 12, 57, 17, 2, -47 },
  { 1148, 28, 26, 36, 4, -50 },
  { 1239, 30, 30, 38, 4, -38 },
  { 1352, 5, 17, 12, 3, -8 },
  { 1363, 16, 2, 21, 3, -19 },
  { 1367, 3, 5, 15, 6, -4 },
  { 1369, 19, 47, 21, 1, -47 },
  { 1481, 29, 49, 38, 4, -48 },
  { 1659, 14, 47, 38, 7, -47 },
  { 1742, 28, 48, 38, 4, -48 },
  { 1910, 29, 49, 38, 3, -48 },
  { 2088, 35, 47, 38, 2, -47 },
  { 2294, 28, 48, 38, 5, -47 },
  { 2462, 30, 49, 38, 4, -48 },
  { 2646, 30, 47, 38, 4, -47 },
  { 2823, 29, 49, 38, 4, -48 },
  { 3001, 29, 49, 38, 4, -48 },
  { 3179, 3, 36, 15, 6, -35 },
  { 3193, 6, 44, 15, 3, -35 },
  { 3226, 30, 30, 38, 4, -39 },
  { 3339, 30, 15, 38, 4, -31 },
  { 3396, 30, 30, 38, 4, -39 },
  { 3509, 22, 49, 27, 3, -48 },
  { 3644, 52, 54, 58, 3, -47 },
  { 3995, 38, 47, 38, 0, -47 },
  { 4219, 30, 47, 40, 7, -47 },
  { 4396, 34, 49, 41, 4, -48 },
  { 4605, 34, 47, 46, 7, -47 },
  { 4805, 25, 47, 36, 7, -47 },
  { 4952, 25, 47, 32, 7, -47 },
  { 5099, 38, 49, 48, 4, -48 },
  { 5332, 33, 47, 47, 7, -47 },
  { 5526, 11, 47, 19, 4, -47 },
  { 5591, 15, 58, 15, -6, -47 },
  { 5700, 30, 47, 37, 7, -47 },
  { 5877, 25, 47, 33, 7, -47 },
  { 6024, 41, 47, 55, 7, -47 },
  { 6265, 32, 47, 46, 7, -47 },
  { 6453, 42, 49, 50, 4, -48 },
  { 6711, 27, 47, 38, 7, -47 },
  { 6870, 42, 59, 50, 4, -48 },
  { 7180, 29, 47, 38, 7, -47 },
  { 7351, 28, 49, 36, 4, -48 },
  { 7523, 33, 47, 33, 0, -47 },
  { 7717, 35, 48, 47, 6, -47 },
  { 7927, 37, 47, 37, 0, -47 },
  { 8145, 53, 47, 57, 2, -47 },
  { 8457, 34, 47, 34, 0, -47 },
  { 8657, 33, 47, 33, 0, -47 },
  { 8851, 34, 47, 38, 2, -47 },
  { 9051, 13, 57, 21, 6, -47 },
  { 9144, 19, 47, 21, 1, -47 },
  { 9256, 13, 57, 21, 2, -47 },
  { 9349, 32, 29, 38, 3, -47 },
  { 9465, 26, 2, 26, 0, 6 },
  { 9472, 11, 11, 16, 3, -51 },
  { 9488, 25, 36, 34, 3, -35 },
  { 9601, 29, 51, 38, 6, -50 },
  { 9786, 25, 37, 31, 4, -36 },
  { 9902, 29, 51, 38, 4, -50 },
  { 10087, 28, 37, 36, 4, -36 },
  { 10217, 21, 50, 18, 1, -50 },
  { 10349, 28, 52, 38, 4, -36 },
  { 10531, 26, 50, 38, 6, -50 },
  { 10694, 4, 48, 14, 5, -48 },
  { 10718, 12, 64, 14, -3, -48 },
  { 10814, 24, 50, 30, 6, -50 },
  { 10964, 2, 50, 14, 6, -50 },
  { 10977, 45, 36, 56, 6, -36 },
  { 11180, 26, 36, 38, 6, -36 },
  { 11297, 30, 37, 38, 4, -36 },
  { 11436, 29, 51, 38, 6, -36 },
  { 11621, 28, 51, 38, 4, -36 },
  { 11800, 18, 35, 25, 6, -35 },
  { 11879, 24, 37, 30, 3, -36 },
  { 11990, 18, 45, 21, 1, -44 },
  { 12092, 27, 36, 38, 5, -35 },
  { 12214, 28, 35, 28, 0, -35 },
  { 12337, 43, 35, 45, 1, -35 },
  { 12526, 28, 35, 32, 2, -35 },
  { 12649, 28, 51, 28, 0, -35 },
  { 12828, 24, 35, 30, 3, -35 },
  { 12933, 18, 57, 22, 2, -47 },
  { 13062, 1, 67, 35, 17, -50 },
  { 13071, 18, 57, 22, 2, -47 },
  { 13200, 30, 6, 38, 4, -26 },
};

const GFXfont NotoSans_Thin66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin66pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_THIN66PT7B_H_
