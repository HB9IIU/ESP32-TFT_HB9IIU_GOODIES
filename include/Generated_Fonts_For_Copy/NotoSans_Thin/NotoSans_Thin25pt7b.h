#ifndef _NOTOSANS_THIN25PT7B_H_
#define _NOTOSANS_THIN25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x40, 0x99, 0x99, 0x99, 0x90, 0x04, 0x10, 0x10, 0x40,
  0x41, 0x01, 0x08, 0x04, 0x20, 0x20, 0x87, 0xFF, 0xC2, 0x08, 0x08, 0x40,
  0x21, 0x01, 0x04, 0x04, 0x10, 0xFF, 0xF8, 0x41, 0x01, 0x08, 0x04, 0x20,
  0x20, 0x80, 0x82, 0x00, 0x08, 0x07, 0x86, 0x9A, 0x20, 0x88, 0x22, 0x08,
  0x82, 0x20, 0x48, 0x0E, 0x00, 0xE0, 0x24, 0x08, 0x82, 0x10, 0x84, 0x21,
  0x08, 0xA2, 0x47, 0xE0, 0x20, 0x3C, 0x04, 0x21, 0x02, 0x10, 0x82, 0x10,
  0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x08, 0x81, 0x04, 0x9E, 0x42, 0x50,
  0xA1, 0x48, 0x4F, 0x28, 0x20, 0x24, 0x10, 0x12, 0x08, 0x11, 0x04, 0x10,
  0x82, 0x08, 0x21, 0x08, 0x10, 0x84, 0x07, 0x80, 0x1F, 0x00, 0x41, 0x01,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x10, 0x04, 0x40, 0x0B, 0x00, 0x18,
  0x00, 0x48, 0x01, 0x08, 0x14, 0x08, 0x28, 0x08, 0x90, 0x09, 0x20, 0x0C,
  0x40, 0x18, 0x40, 0x48, 0x7F, 0x0C, 0xFE, 0x18, 0x88, 0x84, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x41, 0x0C, 0x84, 0x42, 0x21,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x08, 0x02, 0x00, 0x82,
  0x21, 0x6B, 0x87, 0x00, 0xC0, 0x48, 0x21, 0x10, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x55, 0xA0, 0xFC, 0x80, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x3F, 0x08, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x12, 0x02, 0x40,
  0x87, 0xE0, 0x09, 0xD3, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x40, 0x1F, 0x0C, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x1F, 0xFC, 0x3F, 0x98, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x1F, 0x00, 0x18, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x4F, 0xF0, 0x00, 0x40, 0x06, 0x00, 0x50, 0x04, 0x80, 0x24,
  0x02, 0x20, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x8F,
  0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xC8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x05, 0xF0, 0xC1, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x80, 0x9F, 0xE0, 0x0F,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xE0, 0x90,
  0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x47, 0xF0,
  0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x3F, 0x08, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0x90,
  0x21, 0x98, 0x0C, 0x06, 0x61, 0x02, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x02, 0x40, 0xC7, 0xE0, 0x1F, 0x02, 0x0C, 0x40, 0x44, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x03, 0x40, 0x22, 0x05, 0x1F, 0x90, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x87, 0xF0, 0x80, 0x08, 0x40, 0x00, 0x05,
  0x5A, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x00, 0xFE, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x70, 0x70, 0x08, 0x00, 0x81,
  0x00, 0x04, 0x20, 0x00, 0x24, 0x07, 0x82, 0x41, 0x84, 0x24, 0x20, 0x41,
  0x82, 0x04, 0x18, 0x40, 0x41, 0x84, 0x04, 0x18, 0x40, 0x41, 0x84, 0x04,
  0x28, 0x20, 0xC2, 0x41, 0xB2, 0xC4, 0x04, 0x10, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x02, 0x08, 0x08,
  0x20, 0x40, 0x81, 0xFF, 0x08, 0x04, 0x20, 0x10, 0x80, 0x24, 0x00, 0x90,
  0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x18, 0x03,
  0x00, 0xA0, 0x14, 0x04, 0xFF, 0x10, 0x32, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x80, 0xDF, 0xE0, 0x0F, 0xF8, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7F, 0x80,
  0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0xC7, 0xF8, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00,
  0x07, 0xF8, 0x60, 0x12, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x07, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x14, 0x00, 0x50, 0x01, 0x30, 0x04, 0x3F, 0xE0, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF4,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0x70,
  0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x00, 0xD0, 0x11, 0x02,
  0x10, 0x42, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x50, 0x04, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x3A, 0x00, 0xB4, 0x01, 0x68, 0x02, 0xC8, 0x09, 0x90,
  0x13, 0x10, 0x46, 0x20, 0x8C, 0x41, 0x18, 0x44, 0x30, 0x88, 0x60, 0xA0,
  0xC1, 0x41, 0x83, 0x03, 0x02, 0x04, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11,
  0x80, 0x98, 0x09, 0x80, 0x58, 0x03, 0x80, 0x38, 0x01, 0x0F, 0xE0, 0x20,
  0x21, 0x80, 0x22, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50,
  0x01, 0x20, 0x02, 0x30, 0x10, 0x1F, 0xC0, 0xFE, 0x20, 0x68, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA1, 0xCF, 0x82, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x20, 0x21, 0x80, 0x22,
  0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x01, 0x20, 0x02,
  0x30, 0x18, 0x1F, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0xFC, 0x10, 0x32, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x81,
  0x1F, 0xC2, 0x10, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x04, 0x80, 0x50,
  0x04, 0x1F, 0xC4, 0x05, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x5F, 0xF0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x28, 0x01, 0x20, 0x10,
  0xFF, 0x00, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x08, 0x80,
  0x42, 0x01, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x48, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x80, 0x40,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x0A, 0x02, 0x40, 0x90, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x42, 0x11, 0x04, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22,
  0x08, 0x81, 0x20, 0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x05, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x40, 0x12, 0x00, 0x88, 0x08,
  0x20, 0x81, 0x04, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x02, 0x00, 0x30, 0x01,
  0x40, 0x11, 0x01, 0x08, 0x08, 0x20, 0x80, 0x88, 0x04, 0x40, 0x14, 0x00,
  0x40, 0x80, 0x0A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x08, 0x20, 0x42,
  0x01, 0x10, 0x09, 0x00, 0x28, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x02, 0x00, 0x60, 0x05,
  0x00, 0x90, 0x08, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80,
  0x10, 0xFF, 0xC0, 0x84, 0x21, 0x7F, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40,
  0xF3, 0xC5, 0x01, 0x80, 0x60, 0x18, 0x0D, 0x05, 0x7E, 0x40, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x1C, 0x2C, 0x66, 0x02, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x58, 0x0A, 0xFE,
  0x00, 0x1F, 0xC8, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x0C, 0x46, 0x69, 0x03, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0A, 0x01, 0x40, 0x24, 0x0C, 0x7E, 0x80, 0x1F, 0x84, 0x09,
  0x00, 0xA0, 0x18, 0x03, 0x00, 0x7F, 0xF4, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0xFC, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xA4,
  0x0D, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05,
  0x00, 0x90, 0x31, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x28, 0x08, 0xFE,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0x8B, 0x1B, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0xC7, 0xFF, 0xC0, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x1E, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07,
  0x02, 0x82, 0x42, 0x22, 0x12, 0x0A, 0x86, 0x42, 0x11, 0x04, 0x81, 0x40,
  0xA0, 0x20, 0xFF, 0xFF, 0xE0, 0xBF, 0x3F, 0x60, 0x60, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0xBF, 0xB0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x1F, 0xC2, 0x02, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x9F, 0x94,
  0x0B, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x01, 0x50, 0x29, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x00, 0x1F, 0xA4, 0x0D, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x05, 0x00, 0x90, 0x31, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0xBF, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x00, 0x3F, 0xA0, 0x20, 0x10, 0x04, 0x01, 0x80, 0x38,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0F, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03,
  0x3F, 0x40, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42, 0x08, 0x41, 0x08, 0x40,
  0x88, 0x11, 0x01, 0x40, 0x28, 0x06, 0x00, 0x40, 0x80, 0x80, 0xA0, 0x60,
  0x90, 0x50, 0x48, 0x28, 0x22, 0x12, 0x11, 0x11, 0x10, 0x88, 0x88, 0x44,
  0x24, 0x14, 0x12, 0x0A, 0x0A, 0x05, 0x03, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x80, 0x50, 0x22, 0x10, 0x88, 0x12, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x08,
  0x44, 0x09, 0x02, 0x80, 0x40, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42, 0x08,
  0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x40, 0x28, 0x06, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x0E,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x06, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x01, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x71, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x1C, 0x00, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 18, 6, 2, -18 },
  { 4, 4, 7, 8, 2, -18 },
  { 8, 14, 18, 16, 1, -18 },
  { 40, 10, 20, 14, 2, -19 },
  { 65, 17, 18, 20, 1, -18 },
  { 104, 15, 18, 18, 2, -18 },
  { 138, 1, 7, 4, 2, -18 },
  { 139, 5, 22, 6, 1, -18 },
  { 153, 4, 22, 6, 1, -18 },
  { 164, 10, 10, 14, 2, -19 },
  { 177, 12, 12, 14, 1, -15 },
  { 195, 2, 6, 5, 1, -3 },
  { 197, 6, 1, 8, 1, -7 },
  { 198, 1, 1, 6, 2, -1 },
  { 199, 8, 18, 8, 0, -18 },
  { 217, 11, 18, 14, 2, -18 },
  { 242, 5, 18, 14, 3, -18 },
  { 254, 11, 18, 14, 1, -18 },
  { 279, 11, 18, 14, 1, -18 },
  { 304, 13, 18, 14, 1, -18 },
  { 334, 11, 18, 14, 2, -18 },
  { 359, 11, 18, 14, 2, -18 },
  { 384, 12, 18, 14, 1, -18 },
  { 411, 11, 18, 14, 2, -18 },
  { 436, 12, 18, 14, 1, -18 },
  { 463, 1, 13, 6, 2, -13 },
  { 465, 2, 16, 6, 1, -13 },
  { 469, 12, 12, 14, 1, -15 },
  { 487, 12, 6, 14, 1, -12 },
  { 496, 12, 12, 14, 1, -15 },
  { 514, 8, 18, 10, 1, -18 },
  { 532, 20, 21, 22, 1, -18 },
  { 585, 14, 18, 14, 0, -18 },
  { 617, 11, 18, 15, 3, -18 },
  { 642, 13, 18, 15, 2, -18 },
  { 672, 13, 18, 17, 3, -18 },
  { 702, 9, 18, 14, 3, -18 },
  { 723, 9, 18, 12, 3, -18 },
  { 744, 14, 18, 18, 2, -18 },
  { 776, 12, 18, 18, 3, -18 },
  { 803, 4, 18, 7, 2, -18 },
  { 812, 5, 22, 6, -2, -18 },
  { 826, 11, 18, 14, 3, -18 },
  { 851, 9, 18, 13, 3, -18 },
  { 872, 15, 18, 21, 3, -18 },
  { 906, 12, 18, 17, 3, -18 },
  { 933, 15, 18, 19, 2, -18 },
  { 967, 10, 18, 14, 3, -18 },
  { 990, 15, 22, 19, 2, -18 },
  { 1032, 11, 18, 14, 3, -18 },
  { 1057, 11, 18, 14, 1, -18 },
  { 1082, 13, 18, 13, 0, -18 },
  { 1112, 13, 18, 18, 2, -18 },
  { 1142, 14, 18, 14, 0, -18 },
  { 1174, 20, 18, 22, 1, -18 },
  { 1219, 13, 18, 13, 0, -18 },
  { 1249, 13, 18, 13, 0, -18 },
  { 1279, 12, 18, 14, 1, -18 },
  { 1306, 5, 22, 8, 2, -18 },
  { 1320, 8, 18, 8, 0, -18 },
  { 1338, 5, 22, 8, 1, -18 },
  { 1352, 12, 11, 14, 1, -18 },
  { 1369, 10, 1, 10, 0, 2 },
  { 1371, 4, 4, 6, 1, -19 },
  { 1373, 10, 13, 13, 1, -13 },
  { 1390, 11, 19, 15, 2, -19 },
  { 1417, 10, 13, 12, 1, -13 },
  { 1434, 11, 19, 15, 1, -19 },
  { 1461, 11, 13, 14, 1, -13 },
  { 1479, 8, 19, 7, 0, -19 },
  { 1498, 11, 19, 15, 1, -13 },
  { 1525, 10, 19, 14, 2, -19 },
  { 1549, 1, 18, 5, 2, -18 },
  { 1552, 4, 24, 5, -1, -18 },
  { 1564, 9, 19, 11, 2, -19 },
  { 1586, 1, 19, 5, 2, -19 },
  { 1589, 17, 13, 21, 2, -13 },
  { 1617, 10, 13, 14, 2, -13 },
  { 1634, 12, 13, 14, 1, -13 },
  { 1654, 11, 19, 15, 2, -13 },
  { 1681, 11, 19, 15, 1, -13 },
  { 1708, 7, 13, 9, 2, -13 },
  { 1720, 9, 13, 11, 1, -13 },
  { 1735, 7, 16, 8, 0, -16 },
  { 1749, 10, 13, 14, 2, -13 },
  { 1766, 11, 13, 11, 0, -13 },
  { 1784, 17, 13, 17, 0, -13 },
  { 1812, 10, 13, 12, 1, -13 },
  { 1829, 11, 19, 11, 0, -13 },
  { 1856, 9, 13, 11, 1, -13 },
  { 1871, 7, 22, 8, 1, -18 },
  { 1891, 1, 25, 13, 6, -19 },
  { 1895, 7, 22, 8, 1, -18 },
  { 1915, 12, 2, 14, 1, -10 },
};

const GFXfont NotoSans_Thin25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin25pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_THIN25PT7B_H_
