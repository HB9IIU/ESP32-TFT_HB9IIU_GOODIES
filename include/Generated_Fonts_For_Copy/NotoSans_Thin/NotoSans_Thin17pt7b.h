#ifndef _NOTOSANS_THIN17PT7B_H_
#define _NOTOSANS_THIN17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x08, 0x81, 0x10, 0x22, 0x37, 0xF1, 0x10,
  0x22, 0x04, 0x47, 0xEE, 0x12, 0x04, 0x40, 0x88, 0x11, 0x00, 0x10, 0xFA,
  0x44, 0x89, 0x1A, 0x0C, 0x0E, 0x12, 0x24, 0x48, 0x9F, 0xC2, 0x00, 0x70,
  0x91, 0x12, 0x24, 0x44, 0x88, 0xAD, 0x1A, 0x75, 0x49, 0x49, 0x09, 0x22,
  0x24, 0x44, 0x90, 0xF0, 0x3C, 0x10, 0x84, 0x21, 0x08, 0x2C, 0x0C, 0x04,
  0x86, 0x11, 0x82, 0x60, 0x68, 0x19, 0xF9, 0xF0, 0x6A, 0x49, 0x24, 0x92,
  0x44, 0x88, 0x89, 0x22, 0x49, 0x24, 0xA5, 0x20, 0x10, 0x22, 0x4B, 0xE1,
  0x05, 0x11, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0xF0,
  0xF0, 0x80, 0x08, 0x42, 0x21, 0x10, 0x84, 0x42, 0x11, 0x00, 0x7C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0x2E, 0x92,
  0x49, 0x24, 0x90, 0xFC, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41,
  0x07, 0xF0, 0xFC, 0x04, 0x08, 0x10, 0x27, 0x81, 0x81, 0x02, 0x04, 0x0F,
  0xE0, 0x02, 0x01, 0x40, 0x50, 0x24, 0x11, 0x08, 0x42, 0x11, 0x04, 0xFF,
  0xC0, 0x40, 0x10, 0x04, 0x7E, 0x40, 0x40, 0x40, 0x90, 0x6C, 0x02, 0x01,
  0x01, 0x01, 0x02, 0xFC, 0x3E, 0x40, 0x40, 0x80, 0x9C, 0xE2, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x7C, 0x82, 0x82, 0x82, 0x64, 0x18, 0x64, 0x82,
  0x81, 0x81, 0x82, 0x7C, 0x7C, 0x82, 0x82, 0x81, 0x81, 0x82, 0x45, 0x39,
  0x02, 0x02, 0x04, 0xF8, 0x80, 0x80, 0x81, 0xE0, 0x03, 0x0C, 0x30, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x03,
  0x06, 0x18, 0x60, 0x80, 0xF8, 0x42, 0x10, 0x88, 0x88, 0x40, 0x00, 0x80,
  0x1F, 0xC1, 0x01, 0x10, 0x05, 0x0E, 0x18, 0x88, 0xC8, 0x46, 0x42, 0x32,
  0x11, 0x90, 0x8C, 0x7B, 0xA0, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xC0, 0x08,
  0x03, 0x01, 0x40, 0x48, 0x12, 0x08, 0x42, 0x10, 0xFC, 0x40, 0x90, 0x28,
  0x0A, 0x01, 0xFD, 0x06, 0x0C, 0x18, 0x3F, 0xA0, 0xC1, 0x83, 0x06, 0x0F,
  0xE0, 0x3F, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x07, 0xF0, 0xFC, 0x41, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xA0, 0x9F, 0x80, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x1F,
  0xD8, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x7E, 0x01, 0x80, 0x50, 0x14,
  0x04, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xE0, 0x83, 0x0A, 0x24, 0x8A, 0x1C, 0x24, 0x48, 0x89, 0x0A,
  0x0C, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80,
  0x60, 0x1C, 0x0F, 0x03, 0xA0, 0xE8, 0x5A, 0x16, 0x49, 0x92, 0x62, 0x98,
  0xC6, 0x11, 0x81, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x89, 0x89, 0x85, 0x83,
  0x81, 0x81, 0x3F, 0x88, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x28, 0x09, 0x01, 0x1F, 0xC0, 0xFD, 0x06, 0x0C, 0x18, 0x30,
  0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3F, 0x88, 0x09, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x09, 0x01, 0x1E, 0xC0, 0x20,
  0x02, 0x00, 0x20, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x89, 0x0A,
  0x0C, 0x10, 0x7F, 0x02, 0x04, 0x0C, 0x06, 0x03, 0x01, 0x02, 0x04, 0x0F,
  0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x4F, 0xC0, 0x80, 0x60, 0x24, 0x09, 0x04, 0x41, 0x08,
  0x42, 0x20, 0x48, 0x12, 0x05, 0x00, 0xC0, 0x20, 0x82, 0x0C, 0x30, 0x61,
  0x43, 0x0A, 0x14, 0x51, 0x24, 0x89, 0x22, 0x49, 0x14, 0x30, 0xA1, 0x83,
  0x0C, 0x10, 0x20, 0x80, 0xC1, 0x20, 0x88, 0x84, 0x81, 0x40, 0x40, 0x60,
  0x28, 0x22, 0x21, 0x10, 0x50, 0x10, 0x81, 0xA0, 0x90, 0x84, 0x42, 0x40,
  0xA0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x24, 0x24,
  0x42, 0x82, 0x81, 0xFE, 0x88, 0x80, 0x7C, 0x10, 0x41, 0x7E, 0x18, 0x61,
  0xFC, 0x81, 0x02, 0x04, 0x0F, 0xD0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x2F,
  0x80, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x20, 0x3E, 0x02, 0x04, 0x08,
  0x17, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x17, 0xE0, 0x3C, 0x86, 0x0C,
  0x1F, 0xD0, 0x20, 0x40, 0x7E, 0x1C, 0x82, 0x08, 0xF0, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04,
  0x08, 0x1F, 0xC0, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x84, 0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x4F, 0x82, 0x08, 0x20,
  0x8A, 0x4A, 0x28, 0xE2, 0x89, 0x22, 0x84, 0xFF, 0xF8, 0xFB, 0xD0, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x20, 0xFA, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x7C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04,
  0x08, 0x00, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04, 0x08,
  0x10, 0x20, 0xF8, 0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x30, 0x38, 0x10,
  0x41, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x0E, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x7E, 0x83, 0x05, 0x0A, 0x24, 0x45, 0x0A, 0x08,
  0x10, 0x84, 0x30, 0xC5, 0x18, 0xA4, 0x94, 0x94, 0x52, 0x8C, 0x31, 0x84,
  0x10, 0x80, 0x42, 0x42, 0x24, 0x18, 0x08, 0x18, 0x24, 0x42, 0xC1, 0x83,
  0x05, 0x0A, 0x24, 0x45, 0x0A, 0x08, 0x10, 0x20, 0x41, 0x0C, 0x00, 0xFC,
  0x20, 0x84, 0x20, 0x84, 0x20, 0xFC, 0x19, 0x08, 0x42, 0x10, 0x98, 0x21,
  0x08, 0x42, 0x10, 0x60, 0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x21, 0x22,
  0x22, 0x24, 0x80, 0x71, 0x8E,
};

const GFXglyph NotoSans_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 4, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 11, 12, 11, 0, -12 },
  { 22, 7, 14, 10, 1, -13 },
  { 35, 11, 12, 13, 1, -12 },
  { 52, 10, 12, 12, 1, -12 },
  { 67, 1, 4, 3, 1, -12 },
  { 68, 3, 15, 4, 1, -12 },
  { 74, 3, 15, 4, 1, -12 },
  { 80, 7, 7, 9, 1, -13 },
  { 87, 8, 8, 10, 1, -10 },
  { 95, 1, 4, 3, 1, -2 },
  { 96, 4, 1, 5, 1, -5 },
  { 97, 1, 1, 4, 1, -1 },
  { 98, 5, 12, 5, 0, -12 },
  { 106, 8, 12, 10, 1, -12 },
  { 118, 3, 12, 10, 2, -12 },
  { 123, 7, 12, 10, 1, -12 },
  { 134, 7, 12, 10, 1, -12 },
  { 145, 10, 12, 10, 0, -12 },
  { 160, 8, 12, 10, 1, -12 },
  { 172, 8, 12, 10, 1, -12 },
  { 184, 8, 12, 10, 1, -12 },
  { 196, 8, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 1, -12 },
  { 220, 1, 9, 4, 1, -9 },
  { 222, 1, 11, 4, 1, -9 },
  { 224, 8, 8, 10, 1, -10 },
  { 232, 8, 4, 10, 1, -8 },
  { 236, 8, 8, 10, 1, -10 },
  { 244, 5, 12, 7, 1, -12 },
  { 252, 13, 14, 15, 1, -12 },
  { 275, 10, 12, 10, 0, -12 },
  { 290, 7, 12, 10, 2, -12 },
  { 301, 9, 12, 10, 1, -12 },
  { 315, 9, 12, 12, 2, -12 },
  { 329, 6, 12, 9, 2, -12 },
  { 338, 6, 12, 8, 2, -12 },
  { 347, 10, 12, 12, 1, -12 },
  { 362, 8, 12, 12, 2, -12 },
  { 374, 3, 12, 5, 1, -12 },
  { 379, 4, 15, 4, -2, -12 },
  { 387, 7, 12, 9, 2, -12 },
  { 398, 6, 12, 9, 2, -12 },
  { 407, 10, 12, 14, 2, -12 },
  { 422, 8, 12, 12, 2, -12 },
  { 434, 11, 12, 13, 1, -12 },
  { 451, 7, 12, 10, 2, -12 },
  { 462, 11, 15, 13, 1, -12 },
  { 483, 7, 12, 10, 2, -12 },
  { 494, 7, 12, 9, 1, -12 },
  { 505, 9, 12, 9, 0, -12 },
  { 519, 9, 12, 12, 2, -12 },
  { 533, 10, 12, 10, 0, -12 },
  { 548, 13, 12, 15, 1, -12 },
  { 568, 9, 12, 9, 0, -12 },
  { 582, 9, 12, 9, 0, -12 },
  { 596, 8, 12, 10, 1, -12 },
  { 608, 4, 15, 5, 1, -12 },
  { 616, 5, 12, 5, 0, -12 },
  { 624, 4, 15, 5, 0, -12 },
  { 632, 8, 7, 10, 1, -12 },
  { 639, 7, 1, 7, 0, 1 },
  { 640, 3, 3, 4, 1, -13 },
  { 642, 6, 9, 9, 1, -9 },
  { 649, 7, 13, 10, 2, -13 },
  { 661, 7, 9, 8, 1, -9 },
  { 669, 7, 13, 10, 1, -13 },
  { 681, 7, 9, 9, 1, -9 },
  { 689, 6, 13, 5, 0, -13 },
  { 699, 7, 13, 10, 1, -9 },
  { 711, 6, 13, 10, 2, -13 },
  { 721, 1, 12, 4, 1, -12 },
  { 723, 3, 16, 4, -1, -12 },
  { 729, 6, 13, 8, 2, -13 },
  { 739, 1, 13, 4, 1, -13 },
  { 741, 11, 9, 14, 2, -9 },
  { 754, 6, 9, 10, 2, -9 },
  { 761, 8, 9, 10, 1, -9 },
  { 770, 7, 13, 10, 2, -9 },
  { 782, 7, 13, 10, 1, -9 },
  { 794, 4, 9, 6, 2, -9 },
  { 799, 6, 9, 8, 1, -9 },
  { 806, 5, 11, 5, 0, -11 },
  { 813, 7, 9, 10, 1, -9 },
  { 821, 7, 9, 7, 0, -9 },
  { 829, 11, 9, 12, 0, -9 },
  { 842, 8, 9, 8, 0, -9 },
  { 851, 7, 13, 7, 0, -9 },
  { 863, 6, 9, 8, 1, -9 },
  { 870, 5, 15, 6, 0, -12 },
  { 880, 1, 17, 9, 4, -13 },
  { 883, 4, 15, 6, 1, -12 },
  { 891, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Thin17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin17pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_THIN17PT7B_H_
