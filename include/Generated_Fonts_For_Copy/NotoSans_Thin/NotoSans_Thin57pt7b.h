#ifndef _NOTOSANS_THIN57PT7B_H_
#define _NOTOSANS_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0x3F, 0xE0, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x04,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0xFB, 0x7F, 0x03, 0x06, 0x07, 0x0C, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x04, 0x01, 0x80,
  0x08, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x40, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xE1, 0x80, 0x00,
  0x73, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x33, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x40, 0x18, 0x38, 0xF8, 0x31, 0xE0,
  0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x18, 0x70, 0x00, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x01, 0x80, 0x20, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x00, 0x60, 0x20, 0x00, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x01, 0x81, 0x00, 0x00, 0x40, 0x03, 0x06,
  0x07, 0xC0, 0x80, 0x06, 0x08, 0x3F, 0xC1, 0x80, 0x08, 0x30, 0xC0, 0xC3,
  0x00, 0x30, 0xC3, 0x00, 0xC2, 0x00, 0x61, 0x84, 0x00, 0xC6, 0x00, 0x86,
  0x18, 0x01, 0x86, 0x03, 0x08, 0x20, 0x01, 0x06, 0x1C, 0x30, 0x40, 0x02,
  0x07, 0xE0, 0x41, 0x80, 0x06, 0x00, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x02,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x02,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x18, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x06, 0x60, 0x00,
  0xC0, 0x01, 0x18, 0x00, 0x18, 0x00, 0x4C, 0x00, 0x03, 0x00, 0x33, 0x00,
  0x00, 0x60, 0x08, 0x80, 0x00, 0x0C, 0x06, 0x20, 0x00, 0x01, 0x81, 0x08,
  0x00, 0x00, 0x30, 0xC2, 0x00, 0x00, 0x06, 0x60, 0x80, 0x00, 0x00, 0xD0,
  0x20, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x01, 0x00, 0x00, 0x03,
  0x60, 0x60, 0x00, 0x01, 0x8C, 0x0C, 0x00, 0x01, 0xC1, 0x81, 0x80, 0x00,
  0xC0, 0x30, 0x3C, 0x01, 0xE0, 0x06, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x1C, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x10, 0x06, 0x78, 0x10,
  0x3D, 0x0F, 0x11, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x83, 0x00, 0x01, 0x01,
  0x00, 0x03, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x08, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18,
  0x84, 0x60, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xC0, 0xF0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x60,
  0x00, 0x02, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x08, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x38, 0x00, 0xC0,
  0x07, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x07, 0x00, 0xD0, 0x19, 0x07, 0x10, 0xC1, 0x38, 0x17, 0x01, 0xC0, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0xF0,
  0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x80, 0x06, 0x00, 0x01, 0x00, 0x08, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x13, 0xFF, 0xC0, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x7F, 0x80, 0x60, 0xF8, 0xF8, 0x31, 0xC0, 0x06, 0x11,
  0x80, 0x01, 0x89, 0x80, 0x00, 0x65, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x03, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x04, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x07, 0x00, 0x60, 0x01, 0xE0, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x38, 0x07, 0x00, 0x30,
  0x00, 0xE0, 0x30, 0x00, 0x38, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x10,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x38, 0x80, 0x00, 0x0A, 0x30, 0x00, 0x06, 0x86, 0x00,
  0x03, 0x20, 0xC0, 0x03, 0x88, 0x1E, 0x03, 0x82, 0x01, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x1E, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x10, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0x81, 0xE1, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x30, 0x00,
  0x3F, 0xFE, 0x00, 0x62, 0x00, 0x0E, 0x00, 0x20, 0x02, 0x60, 0x01, 0xC0,
  0x02, 0x00, 0x36, 0x00, 0x30, 0x00, 0x60, 0x03, 0x40, 0x02, 0x00, 0x06,
  0x00, 0x34, 0x00, 0x60, 0x00, 0x60, 0x03, 0xC0, 0x04, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x60, 0x03, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x3C, 0x00,
  0x80, 0x00, 0x60, 0x03, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x80,
  0x00, 0x40, 0x03, 0xC0, 0x08, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0xC0, 0x00,
  0xE0, 0x06, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x60, 0x01, 0x60,
  0x0C, 0x40, 0x06, 0x00, 0x32, 0x00, 0xC6, 0x00, 0x30, 0x06, 0x30, 0x18,
  0x60, 0x01, 0xFF, 0xC1, 0xFF, 0x02, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x08, 0x00, 0x07, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x08, 0x00, 0x0F, 0x03, 0xFF, 0xFE, 0x00,
  0x80, 0x03, 0xF0, 0x20, 0x00, 0x07, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x20, 0x00, 0x03, 0x88, 0x00,
  0x03, 0x82, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x20, 0x0F, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x0F, 0x80, 0x20, 0x00, 0x07, 0x80, 0x80, 0x00, 0x07,
  0x02, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x07,
  0x02, 0x00, 0x00, 0x38, 0x08, 0x00, 0x07, 0x80, 0x20, 0x0F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x03, 0x80, 0x00, 0x01, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0xFF, 0xCF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x63, 0xFF, 0x07, 0xF0, 0x00,
  0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x06, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0xE0, 0x00, 0x08, 0x78,
  0x00, 0x02, 0x33, 0x00, 0x00, 0x98, 0x60, 0x00, 0x2C, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x08, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x20, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x0C, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x00,
  0x0F, 0xB0, 0x00, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x00, 0x1B, 0x98, 0x00,
  0x00, 0x01, 0xB8, 0x80, 0x00, 0x00, 0x13, 0x8C, 0x00, 0x00, 0x03, 0x38,
  0xC0, 0x00, 0x00, 0x23, 0x84, 0x00, 0x00, 0x06, 0x38, 0x60, 0x00, 0x00,
  0x43, 0x82, 0x00, 0x00, 0x0C, 0x38, 0x30, 0x00, 0x00, 0xC3, 0x83, 0x00,
  0x00, 0x08, 0x38, 0x10, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00, 0x10, 0x38,
  0x08, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x02,
  0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x06, 0x00, 0x04, 0x03, 0x80, 0x20,
  0x00, 0xC0, 0x38, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x00, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x01, 0x00, 0x38, 0x00, 0x80, 0x30,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x00, 0x40, 0x20, 0x03, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x40, 0x03, 0x80, 0x02, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x80, 0x03, 0x80, 0x01, 0x18, 0x00, 0x38, 0x00, 0x19, 0x80,
  0x03, 0x80, 0x01, 0x90, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38,
  0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x20, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x80, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x02, 0x00, 0x07,
  0x84, 0x00, 0x01, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00,
  0x00, 0xC8, 0x00, 0x07, 0x10, 0x00, 0x38, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x2D, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x20, 0x00, 0x3C, 0x10, 0x00, 0x07, 0x08, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x06, 0x20, 0x00, 0x06, 0x10, 0x00, 0x06,
  0x08, 0x00, 0x0E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0x0C,
  0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00,
  0x30, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xE0,
  0x3F, 0x03, 0x80, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x61, 0xF0, 0x01, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00, 0x06, 0x60, 0x00, 0x05,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x81, 0x00, 0x01, 0x84, 0x00,
  0x06, 0x04, 0x00, 0x04, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x60, 0x00,
  0x40, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x00, 0x80, 0x03, 0x02, 0x00, 0x0C,
  0x03, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x40, 0x06, 0x00, 0x40, 0x04, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x08,
  0x03, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x20, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x04, 0x06, 0x00, 0x04, 0x06,
  0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0x81, 0x00, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x46, 0x00, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x19, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08,
  0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x20, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0,
  0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x03, 0x18, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x3F,
  0xFC, 0x07, 0x80, 0x38, 0x20, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xE0,
  0x3F, 0xE1, 0x0F, 0x00, 0x08, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1A, 0x80, 0x00, 0x96, 0x00, 0x18,
  0x9C, 0x03, 0x84, 0x3F, 0xF8, 0x20, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x03, 0xE0,
  0x06, 0x0F, 0xFE, 0x03, 0x1C, 0x01, 0xC1, 0x98, 0x00, 0x30, 0xD8, 0x00,
  0x0C, 0x68, 0x00, 0x03, 0x2C, 0x00, 0x01, 0x94, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x27, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x31, 0x30, 0x00,
  0x30, 0x8C, 0x00, 0x30, 0x43, 0x80, 0x70, 0x20, 0x7F, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x08, 0x07,
  0xFF, 0x04, 0x0E, 0x00, 0xC2, 0x0C, 0x00, 0x31, 0x0C, 0x00, 0x0C, 0x8C,
  0x00, 0x03, 0x4C, 0x00, 0x00, 0xA6, 0x00, 0x00, 0x72, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x14, 0x40, 0x00, 0x1A, 0x30, 0x00, 0x19, 0x0E,
  0x00, 0x18, 0x83, 0xC0, 0x38, 0x40, 0x7F, 0xF0, 0x20, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x10, 0x00, 0x06, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x02, 0x03, 0xC0, 0x0E, 0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x1F, 0xF0, 0x0C, 0x04, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x40, 0xE0, 0x0E,
  0x20, 0xC0, 0x01, 0x90, 0xC0, 0x00, 0x48, 0xC0, 0x00, 0x14, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x07, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x03, 0x98, 0x00, 0x01,
  0x46, 0x00, 0x01, 0xA3, 0x80, 0x01, 0x90, 0xE0, 0x01, 0x88, 0x1C, 0x03,
  0x84, 0x07, 0xFF, 0x02, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x06, 0x0F, 0x80, 0x0E, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x18, 0x3F, 0xF8, 0x31, 0xC0, 0x1C, 0x66, 0x00, 0x1C, 0xD8, 0x00,
  0x19, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x17, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x7D, 0x80, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0xC0, 0x70, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x03, 0x3F, 0x83, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0xE0, 0x01, 0x8D, 0x80, 0x0C, 0xC4, 0x00, 0x6C, 0x30, 0x03,
  0xC0, 0xC0, 0x1C, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x30, 0x01,
  0x81, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x07, 0x01, 0x07, 0xFE, 0x01, 0xFF, 0xC2, 0x18, 0x06, 0x07, 0x01, 0xC4,
  0x40, 0x06, 0x18, 0x00, 0xC9, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x05,
  0x80, 0x01, 0xB8, 0x00, 0x0E, 0x00, 0x01, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x00,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x01, 0xE0, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x01, 0x03, 0xFF, 0x82, 0x1C,
  0x01, 0xC4, 0x60, 0x01, 0xC9, 0x80, 0x01, 0x92, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0x70, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x1E,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x40, 0xFF,
  0xF0, 0x20, 0xE0, 0x1C, 0x11, 0xC0, 0x03, 0x0C, 0x80, 0x00, 0xC6, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x09, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x02, 0x78, 0x00, 0x03, 0x34, 0x00, 0x03, 0x1B, 0x00, 0x01, 0x8C, 0xC0,
  0x03, 0x86, 0x38, 0x07, 0x83, 0x07, 0xFF, 0x01, 0x80, 0x10, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x40, 0xE0, 0x1C, 0x20, 0xC0,
  0x03, 0x10, 0xC0, 0x00, 0xC8, 0xC0, 0x00, 0x34, 0xC0, 0x00, 0x0A, 0x40,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x02, 0x98, 0x00, 0x03, 0x4C, 0x00,
  0x01, 0x23, 0x00, 0x01, 0x90, 0xC0, 0x01, 0x98, 0x38, 0x03, 0x8C, 0x07,
  0xFF, 0x06, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x31, 0x87, 0xFF, 0x18,
  0x06, 0x40, 0x0D, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7A, 0x00, 0x3F, 0xFF, 0x03,
  0x80, 0x1E, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x6C, 0x00, 0x07, 0x7C, 0x00,
  0xE0, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xFE,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x01, 0x01, 0xFF, 0x00, 0x38,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0xD6,
  0x00, 0x02, 0x4C, 0x00, 0x31, 0x1C, 0x03, 0x84, 0x1F, 0xF8, 0x10, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30,
  0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x04,
  0x01, 0x80, 0x02, 0x00, 0x40, 0x03, 0x00, 0x30, 0x01, 0x00, 0x08, 0x01,
  0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00, 0x60,
  0x20, 0x00, 0x10, 0x30, 0x00, 0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xD0, 0x00, 0x0C,
  0x00, 0x04, 0xC0, 0x00, 0xF0, 0x00, 0x26, 0x00, 0x04, 0x80, 0x03, 0x10,
  0x00, 0x24, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80,
  0x04, 0x30, 0x00, 0x84, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00,
  0x41, 0x80, 0x10, 0x30, 0x02, 0x04, 0x00, 0x80, 0x80, 0x30, 0x30, 0x0C,
  0x04, 0x01, 0x01, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x30, 0x30, 0x04, 0x04, 0x01, 0x81, 0x80, 0x30, 0x20, 0x04, 0x08, 0x01,
  0x83, 0x00, 0x30, 0x40, 0x04, 0x10, 0x01, 0x86, 0x00, 0x20, 0x80, 0x04,
  0x30, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x22,
  0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x26, 0x00, 0x0D, 0x00, 0x01, 0xA0,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x08, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x04, 0x00, 0x04, 0x06, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x04, 0x00, 0x0C,
  0x03, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0x80,
  0x60, 0x00, 0x60, 0x20, 0x00, 0x10, 0x30, 0x00, 0x08, 0x18, 0x00, 0x06,
  0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x3F, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x07, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x16, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x06, 0x80, 0x01,
  0xFF, 0x00,
};

const GFXglyph NotoSans_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 41, 13, 5, -41 },
  { 17, 10, 15, 18, 4, -41 },
  { 36, 33, 41, 37, 2, -41 },
  { 206, 23, 46, 32, 4, -43 },
  { 339, 39, 42, 45, 3, -41 },
  { 544, 34, 42, 40, 4, -41 },
  { 723, 2, 15, 10, 4, -41 },
  { 727, 11, 50, 15, 2, -41 },
  { 796, 10, 50, 15, 2, -41 },
  { 859, 24, 23, 31, 4, -43 },
  { 928, 26, 26, 32, 3, -33 },
  { 1013, 5, 14, 10, 2, -7 },
  { 1022, 14, 1, 18, 2, -16 },
  { 1024, 3, 3, 13, 5, -3 },
  { 1026, 17, 41, 18, 1, -41 },
  { 1114, 25, 42, 32, 4, -41 },
  { 1246, 12, 41, 32, 6, -41 },
  { 1308, 25, 41, 32, 3, -41 },
  { 1437, 25, 42, 32, 3, -41 },
  { 1569, 31, 41, 32, 1, -41 },
  { 1728, 25, 42, 32, 4, -41 },
  { 1860, 25, 42, 32, 4, -41 },
  { 1992, 26, 41, 32, 3, -41 },
  { 2126, 25, 42, 32, 4, -41 },
  { 2258, 26, 42, 32, 3, -41 },
  { 2395, 3, 30, 13, 5, -30 },
  { 2407, 6, 37, 13, 2, -30 },
  { 2435, 26, 25, 32, 3, -33 },
  { 2517, 26, 13, 32, 3, -27 },
  { 2560, 26, 25, 32, 3, -33 },
  { 2642, 19, 41, 24, 2, -41 },
  { 2740, 44, 46, 50, 3, -40 },
  { 2993, 33, 41, 33, 0, -41 },
  { 3163, 26, 41, 35, 6, -41 },
  { 3297, 29, 42, 35, 4, -41 },
  { 3450, 30, 41, 39, 6, -41 },
  { 3604, 22, 41, 31, 6, -41 },
  { 3717, 22, 41, 28, 6, -41 },
  { 3830, 32, 42, 41, 4, -41 },
  { 3998, 28, 41, 40, 6, -41 },
  { 4142, 10, 41, 16, 3, -41 },
  { 4194, 14, 51, 13, -6, -41 },
  { 4284, 26, 41, 32, 6, -41 },
  { 4418, 22, 41, 29, 6, -41 },
  { 4531, 36, 41, 48, 6, -41 },
  { 4716, 28, 41, 40, 6, -41 },
  { 4860, 35, 42, 43, 4, -41 },
  { 5044, 23, 41, 33, 6, -41 },
  { 5162, 35, 51, 43, 4, -41 },
  { 5386, 25, 41, 33, 6, -41 },
  { 5515, 25, 42, 31, 3, -41 },
  { 5647, 29, 41, 29, 0, -41 },
  { 5796, 30, 42, 41, 5, -41 },
  { 5954, 32, 41, 32, 0, -41 },
  { 6118, 46, 41, 50, 2, -41 },
  { 6354, 29, 41, 29, 0, -41 },
  { 6503, 29, 41, 29, 0, -41 },
  { 6652, 29, 41, 33, 2, -41 },
  { 6801, 11, 50, 18, 5, -41 },
  { 6870, 17, 41, 18, 1, -41 },
  { 6958, 12, 50, 18, 1, -41 },
  { 7033, 27, 25, 32, 3, -41 },
  { 7118, 22, 2, 22, 0, 5 },
  { 7124, 10, 9, 14, 2, -44 },
  { 7136, 21, 32, 29, 3, -31 },
  { 7220, 25, 44, 33, 5, -43 },
  { 7358, 22, 32, 27, 3, -31 },
  { 7446, 25, 44, 33, 3, -43 },
  { 7584, 24, 32, 31, 3, -31 },
  { 7680, 18, 44, 16, 1, -44 },
  { 7779, 25, 45, 33, 3, -31 },
  { 7920, 23, 43, 33, 5, -43 },
  { 8044, 3, 41, 12, 4, -41 },
  { 8060, 10, 55, 12, -3, -41 },
  { 8129, 21, 43, 26, 5, -43 },
  { 8242, 2, 43, 12, 5, -43 },
  { 8253, 39, 31, 49, 5, -31 },
  { 8405, 23, 31, 33, 5, -31 },
  { 8495, 26, 32, 33, 3, -31 },
  { 8599, 25, 44, 33, 5, -31 },
  { 8737, 25, 44, 33, 3, -31 },
  { 8875, 15, 31, 21, 5, -31 },
  { 8934, 21, 32, 26, 2, -31 },
  { 9018, 16, 39, 18, 1, -38 },
  { 9096, 22, 31, 33, 5, -30 },
  { 9182, 25, 30, 25, 0, -30 },
  { 9276, 37, 30, 39, 1, -30 },
  { 9415, 25, 30, 27, 1, -30 },
  { 9509, 25, 44, 24, 0, -30 },
  { 9647, 22, 30, 26, 2, -30 },
  { 9730, 16, 50, 19, 1, -41 },
  { 9830, 2, 57, 31, 14, -43 },
  { 9845, 16, 50, 19, 2, -41 },
  { 9945, 26, 5, 32, 3, -23 },
};

const GFXfont NotoSans_Thin57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin57pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_THIN57PT7B_H_
