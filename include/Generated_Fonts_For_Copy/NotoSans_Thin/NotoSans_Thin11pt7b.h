#ifndef _NOTOSANS_THIN11PT7B_H_
#define _NOTOSANS_THIN11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x24, 0x49, 0xD9, 0x42, 0x9F, 0x92, 0x24, 0x7C, 0xCC,
  0x75, 0x5F, 0x40, 0xC5, 0x52, 0xA5, 0xFD, 0x25, 0x4A, 0xA7, 0x72, 0x49,
  0x18, 0xA6, 0x58, 0xBD, 0xE0, 0x5A, 0xAA, 0x50, 0x95, 0x55, 0x60, 0x4D,
  0x69, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xE0, 0x80, 0x24, 0xA4, 0xA4, 0xF4,
  0x63, 0x18, 0xC6, 0x3E, 0x74, 0x92, 0x49, 0xF1, 0x11, 0x24, 0x4F, 0xF1,
  0x15, 0x31, 0x1F, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82, 0xF4, 0x21, 0xE0,
  0x84, 0x3E, 0x74, 0x21, 0xE8, 0xC6, 0x3E, 0xF8, 0x84, 0x22, 0x11, 0x08,
  0xF4, 0x64, 0xC9, 0x46, 0x3E, 0xF4, 0xA3, 0x1F, 0x04, 0x5C, 0x84, 0x40,
  0x18, 0x3E, 0x30, 0x70, 0xFF, 0xC0, 0xC1, 0x8F, 0x80, 0xF1, 0x11, 0x24,
  0x04, 0x3C, 0xC3, 0x99, 0xA5, 0xA5, 0xA5, 0xBE, 0x80, 0x7C, 0x10, 0xC2,
  0x92, 0x79, 0x18, 0x61, 0xF4, 0x63, 0xE8, 0xC6, 0x3F, 0x7C, 0x21, 0x08,
  0x42, 0x0F, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0xF8, 0x8F, 0x88, 0x8F,
  0xF8, 0x88, 0xF8, 0x88, 0x7E, 0x08, 0x20, 0x9E, 0x18, 0x5F, 0x86, 0x18,
  0x7F, 0x86, 0x18, 0x61, 0xFF, 0x55, 0x55, 0x70, 0x8C, 0xA9, 0x8A, 0x4A,
  0x51, 0x88, 0x88, 0x88, 0x8F, 0x83, 0x07, 0x1E, 0x3A, 0xB5, 0x64, 0xC9,
  0x86, 0x1C, 0x69, 0x96, 0x58, 0xE1, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61,
  0x3C, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61,
  0x3C, 0x08, 0x10, 0xF4, 0x63, 0x1F, 0x4A, 0x51, 0xF8, 0x8C, 0x31, 0x1F,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E,
  0x86, 0x14, 0x52, 0x48, 0xA3, 0x08, 0x88, 0xC4, 0x53, 0x2A, 0x95, 0x52,
  0x98, 0x88, 0x44, 0x85, 0x25, 0x08, 0x21, 0x44, 0xA1, 0x86, 0x24, 0x94,
  0x20, 0x82, 0x08, 0x7C, 0x20, 0x84, 0x20, 0x84, 0x3F, 0xEA, 0xAA, 0xB0,
  0x91, 0x24, 0x49, 0xD5, 0x55, 0x70, 0x10, 0xC4, 0x92, 0x84, 0xF0, 0xC0,
  0xE1, 0x79, 0x9F, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x78, 0x88, 0x8F, 0x11,
  0x79, 0x99, 0x9F, 0x79, 0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0x79, 0x99,
  0x9F, 0x11, 0xE0, 0x88, 0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x5C, 0x88,
  0x9A, 0xCC, 0xA9, 0xFF, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99,
  0x99, 0x74, 0x63, 0x18, 0xF8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0xF9,
  0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0x7C, 0x18, 0x20, 0xF8, 0x5D,
  0x24, 0x98, 0x99, 0x99, 0x9F, 0x8C, 0x54, 0xA6, 0x10, 0x93, 0x26, 0x6B,
  0x56, 0x48, 0x80, 0x8A, 0x88, 0x45, 0x44, 0x8C, 0x54, 0xA6, 0x10, 0x88,
  0x80, 0x78, 0x88, 0x44, 0x7C, 0x29, 0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC4,
  0x92, 0x49, 0x38, 0xF8,
};

const GFXglyph NotoSans_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 7, 8, 7, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 7, 8, 9, 1, -8 },
  { 22, 6, 8, 8, 1, -8 },
  { 28, 1, 3, 2, 0, -8 },
  { 29, 2, 10, 3, 0, -8 },
  { 32, 2, 10, 3, 0, -8 },
  { 35, 4, 4, 6, 1, -8 },
  { 37, 5, 5, 6, 1, -6 },
  { 41, 1, 2, 2, 0, -1 },
  { 42, 3, 1, 4, 0, -3 },
  { 43, 1, 1, 2, 1, -1 },
  { 44, 3, 8, 4, 0, -8 },
  { 47, 5, 8, 6, 1, -8 },
  { 52, 3, 8, 6, 1, -8 },
  { 55, 4, 8, 6, 1, -8 },
  { 59, 4, 8, 6, 1, -8 },
  { 63, 6, 8, 6, 0, -8 },
  { 69, 5, 8, 6, 1, -8 },
  { 74, 5, 8, 6, 1, -8 },
  { 79, 5, 8, 6, 1, -8 },
  { 84, 5, 8, 6, 1, -8 },
  { 89, 5, 8, 6, 1, -8 },
  { 94, 1, 6, 2, 1, -6 },
  { 95, 2, 7, 2, 0, -6 },
  { 97, 5, 4, 6, 1, -6 },
  { 100, 5, 2, 6, 1, -5 },
  { 102, 5, 4, 6, 1, -6 },
  { 105, 4, 8, 5, 0, -8 },
  { 109, 8, 9, 10, 1, -8 },
  { 118, 6, 8, 6, 0, -8 },
  { 124, 5, 8, 7, 1, -8 },
  { 129, 5, 8, 7, 1, -8 },
  { 134, 6, 8, 8, 1, -8 },
  { 140, 4, 8, 6, 1, -8 },
  { 144, 4, 8, 5, 1, -8 },
  { 148, 6, 8, 8, 1, -8 },
  { 154, 6, 8, 8, 1, -8 },
  { 160, 1, 8, 3, 1, -8 },
  { 161, 2, 10, 3, -1, -8 },
  { 164, 5, 8, 6, 1, -8 },
  { 169, 4, 8, 6, 1, -8 },
  { 173, 7, 8, 9, 1, -8 },
  { 180, 6, 8, 8, 1, -8 },
  { 186, 7, 8, 8, 1, -8 },
  { 193, 5, 8, 6, 1, -8 },
  { 198, 7, 10, 8, 1, -8 },
  { 207, 5, 8, 6, 1, -8 },
  { 212, 4, 8, 6, 1, -8 },
  { 216, 6, 8, 6, 0, -8 },
  { 222, 6, 8, 8, 1, -8 },
  { 228, 6, 8, 6, 0, -8 },
  { 234, 9, 8, 10, 0, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 2, 10, 3, 1, -8 },
  { 264, 3, 8, 4, 0, -8 },
  { 267, 2, 10, 3, 0, -8 },
  { 270, 6, 5, 6, 0, -8 },
  { 274, 4, 1, 4, 0, 1 },
  { 275, 2, 1, 3, 0, -8 },
  { 276, 4, 6, 6, 1, -6 },
  { 279, 5, 8, 6, 1, -8 },
  { 284, 4, 6, 5, 1, -6 },
  { 287, 4, 8, 6, 1, -8 },
  { 291, 4, 6, 6, 1, -6 },
  { 294, 4, 8, 3, 0, -8 },
  { 298, 4, 9, 6, 1, -6 },
  { 303, 4, 8, 6, 1, -8 },
  { 307, 1, 8, 2, 1, -8 },
  { 308, 2, 11, 2, -1, -8 },
  { 311, 4, 8, 5, 1, -8 },
  { 315, 1, 8, 2, 1, -8 },
  { 316, 7, 6, 9, 1, -6 },
  { 322, 4, 6, 6, 1, -6 },
  { 325, 5, 6, 6, 1, -6 },
  { 329, 5, 9, 6, 1, -6 },
  { 335, 4, 9, 6, 1, -6 },
  { 340, 3, 6, 4, 1, -6 },
  { 343, 5, 6, 5, 0, -6 },
  { 347, 3, 7, 4, 0, -7 },
  { 350, 4, 6, 6, 1, -6 },
  { 353, 5, 6, 5, 0, -6 },
  { 357, 7, 6, 8, 0, -6 },
  { 363, 5, 6, 5, 0, -6 },
  { 367, 5, 9, 5, 0, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 3, 10, 4, 0, -8 },
  { 381, 1, 11, 6, 2, -8 },
  { 383, 3, 10, 4, 0, -8 },
  { 387, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_Thin11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin11pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_THIN11PT7B_H_
