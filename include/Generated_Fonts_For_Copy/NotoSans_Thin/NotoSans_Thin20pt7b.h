#ifndef _NOTOSANS_THIN20PT7B_H_
#define _NOTOSANS_THIN20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22, 0x08, 0x4F,
  0xFE, 0x22, 0x04, 0x40, 0x88, 0x21, 0x1F, 0xFC, 0x88, 0x11, 0x02, 0x20,
  0x84, 0x00, 0x08, 0x3F, 0x48, 0x88, 0x88, 0x88, 0x48, 0x38, 0x0E, 0x09,
  0x09, 0x09, 0x09, 0x89, 0x7E, 0x08, 0x78, 0x22, 0x11, 0x08, 0x44, 0x21,
  0x20, 0x84, 0x82, 0x14, 0xC8, 0x54, 0x92, 0xA1, 0x32, 0x84, 0x12, 0x10,
  0x88, 0x42, 0x21, 0x10, 0x88, 0x41, 0xE0, 0x0C, 0x03, 0x30, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x30, 0x14, 0x01, 0x80, 0x64, 0x14, 0x21, 0x81, 0x28,
  0x0A, 0x80, 0x44, 0x0A, 0x3F, 0x10, 0xF8, 0x29, 0x49, 0x24, 0x92, 0x49,
  0x12, 0x20, 0x89, 0x12, 0x49, 0x24, 0x92, 0x52, 0x80, 0x08, 0x04, 0x22,
  0x2F, 0xE0, 0x80, 0xA0, 0x88, 0x44, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x6A, 0x80, 0xF8, 0x80, 0x04, 0x10,
  0x82, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x00, 0x1C, 0x11, 0x90,
  0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A,
  0x08, 0xF8, 0x17, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7E, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07,
  0xFC, 0x7E, 0x40, 0x80, 0x20, 0x10, 0x10, 0x18, 0xF0, 0x06, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x17, 0xF0, 0x01, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x88,
  0x21, 0x04, 0x21, 0x04, 0x40, 0x9F, 0xFC, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x03, 0xE0, 0x0C, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x17, 0xF0, 0x07, 0x0C, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x04, 0xFC, 0xFF, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x3F, 0x20, 0x50, 0x28, 0x14, 0x11, 0x10, 0x70, 0x46, 0x40,
  0xC0, 0x60, 0x30, 0x14, 0x09, 0xF8, 0x7E, 0x20, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0xC7, 0x1C, 0x80, 0x40, 0x40, 0x20, 0x27, 0xE0, 0xC0, 0x20,
  0x50, 0x00, 0x1A, 0xA0, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x00, 0xFC, 0x10, 0x41, 0x04, 0x11,
  0x88, 0x20, 0x82, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x10, 0x08, 0x20, 0x04,
  0x40, 0x02, 0x43, 0xE2, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21,
  0x88, 0x22, 0x88, 0x62, 0x87, 0x9C, 0x40, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0F, 0xE0, 0x04, 0x00, 0x60, 0x0A, 0x00, 0x90, 0x09, 0x01, 0x08, 0x10,
  0x82, 0x08, 0x3F, 0x82, 0x04, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01, 0xFF,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0xF9, 0x02, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x17, 0xF0, 0x1F, 0xE4, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x80, 0xFF,
  0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x40, 0x48, 0x11, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07,
  0xC1, 0x83, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83,
  0xF8, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x1F, 0xE0, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x81, 0xC1, 0x21,
  0x11, 0x09, 0x05, 0x03, 0x41, 0x10, 0x88, 0x42, 0x20, 0x90, 0x48, 0x14,
  0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x0E, 0x00, 0xF0, 0x0B, 0x40, 0x5A, 0x02, 0xD0,
  0x26, 0x41, 0x32, 0x11, 0x88, 0x8C, 0x44, 0x61, 0x43, 0x0A, 0x18, 0x60,
  0xC1, 0x04, 0x80, 0x70, 0x1A, 0x06, 0x81, 0x90, 0x62, 0x18, 0x86, 0x11,
  0x82, 0x60, 0x98, 0x16, 0x03, 0x80, 0xE0, 0x10, 0x07, 0x80, 0xC2, 0x08,
  0x08, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10, 0x7F, 0x00, 0xFE, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07,
  0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10, 0x7B, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x14, 0x0A,
  0x09, 0xF8, 0x84, 0x42, 0x20, 0x90, 0x28, 0x14, 0x04, 0x7F, 0x40, 0x20,
  0x10, 0x08, 0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x10, 0x17,
  0xF0, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x8F,
  0xC0, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x08, 0x20, 0x84,
  0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0x40, 0x08, 0x00, 0x81, 0x01, 0x81,
  0x01, 0x82, 0x82, 0x82, 0x82, 0x42, 0x82, 0x42, 0x44, 0x44, 0x44, 0x24,
  0x44, 0x24, 0x24, 0x28, 0x28, 0x28, 0x28, 0x18, 0x28, 0x10, 0x10, 0x10,
  0x10, 0xC0, 0x50, 0x22, 0x10, 0x44, 0x12, 0x03, 0x00, 0x40, 0x30, 0x12,
  0x04, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x10, 0x80, 0x50, 0x24, 0x08, 0x84,
  0x21, 0x04, 0x81, 0x20, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF8, 0x0C, 0x0A, 0x04, 0x84, 0x42, 0x12, 0x09, 0x03, 0x01, 0xFF,
  0x88, 0x80, 0x3C, 0x42, 0x01, 0x01, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x83,
  0x7D, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFE, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x11, 0xEB, 0x0D, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C, 0xFA, 0x1E, 0x10, 0x90, 0x50,
  0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x20, 0x0F, 0xC0, 0x1E, 0x40, 0x81,
  0x0F, 0x84, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1E,
  0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xCF, 0xA0,
  0x10, 0x08, 0x06, 0x04, 0xFC, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x9F, 0xFC, 0x10, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x30, 0xA2, 0x48, 0xA1, 0xC2, 0x44, 0x48, 0x90, 0xA0, 0x80, 0xFF, 0xFE,
  0xB8, 0xF6, 0x28, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x0C, 0x10, 0x60, 0x82, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xA0, 0x8F, 0x80, 0xBC, 0x61, 0x20, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x40, 0xBF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x1E, 0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xCF,
  0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x7F, 0x02, 0x04, 0x04, 0x07, 0x01, 0x01, 0x02, 0x07, 0xF0, 0x20,
  0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xC0, 0x90, 0x48,
  0x24, 0x21, 0x10, 0x90, 0x48, 0x14, 0x0C, 0x02, 0x00, 0x81, 0x0C, 0x18,
  0x50, 0xC2, 0x86, 0x14, 0x48, 0x92, 0x48, 0x92, 0x45, 0x0A, 0x28, 0x60,
  0x81, 0x04, 0x08, 0x81, 0x82, 0x44, 0x24, 0x28, 0x10, 0x18, 0x24, 0x44,
  0x82, 0x81, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x90, 0x48, 0x14,
  0x0C, 0x02, 0x01, 0x01, 0x00, 0x80, 0x81, 0x80, 0xFE, 0x04, 0x10, 0x20,
  0x82, 0x08, 0x10, 0x41, 0x03, 0xF8, 0x39, 0x10, 0x84, 0x21, 0x08, 0x82,
  0x10, 0x84, 0x21, 0x04, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10,
  0x82, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0x78, 0xC3, 0x80,
};

const GFXglyph NotoSans_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 11, 14, 13, 1, -14 },
  { 26, 8, 16, 11, 1, -15 },
  { 42, 14, 14, 16, 1, -14 },
  { 67, 12, 15, 14, 1, -15 },
  { 90, 1, 5, 3, 1, -14 },
  { 91, 3, 17, 5, 1, -14 },
  { 98, 3, 17, 5, 1, -14 },
  { 105, 9, 8, 11, 1, -15 },
  { 114, 9, 10, 11, 1, -12 },
  { 126, 2, 5, 4, 1, -2 },
  { 128, 5, 1, 6, 1, -6 },
  { 129, 1, 1, 4, 2, -1 },
  { 130, 6, 14, 6, 0, -14 },
  { 141, 9, 15, 11, 1, -15 },
  { 158, 4, 14, 11, 2, -14 },
  { 165, 9, 14, 11, 1, -14 },
  { 181, 9, 14, 11, 1, -14 },
  { 197, 11, 14, 11, 0, -14 },
  { 217, 9, 14, 11, 1, -14 },
  { 233, 9, 15, 11, 1, -15 },
  { 250, 9, 14, 11, 1, -14 },
  { 266, 9, 14, 11, 1, -14 },
  { 282, 9, 14, 11, 1, -14 },
  { 298, 1, 11, 4, 2, -11 },
  { 300, 2, 14, 4, 1, -11 },
  { 304, 9, 9, 11, 1, -12 },
  { 315, 9, 4, 11, 1, -9 },
  { 320, 9, 9, 11, 1, -12 },
  { 331, 6, 14, 8, 1, -14 },
  { 342, 16, 16, 18, 1, -14 },
  { 374, 12, 14, 12, 0, -14 },
  { 395, 9, 14, 12, 2, -14 },
  { 411, 11, 14, 12, 1, -14 },
  { 431, 11, 14, 14, 2, -14 },
  { 451, 8, 14, 11, 2, -14 },
  { 465, 8, 14, 10, 2, -14 },
  { 479, 12, 15, 14, 1, -15 },
  { 502, 10, 14, 14, 2, -14 },
  { 520, 3, 14, 6, 1, -14 },
  { 526, 5, 17, 5, -2, -14 },
  { 537, 9, 14, 11, 2, -14 },
  { 553, 8, 14, 10, 2, -14 },
  { 567, 13, 14, 17, 2, -14 },
  { 590, 10, 14, 14, 2, -14 },
  { 608, 13, 15, 15, 1, -15 },
  { 633, 8, 14, 11, 2, -14 },
  { 647, 13, 18, 15, 1, -15 },
  { 677, 9, 14, 12, 2, -14 },
  { 693, 9, 14, 11, 1, -14 },
  { 709, 10, 14, 10, 0, -14 },
  { 727, 10, 14, 14, 2, -14 },
  { 745, 11, 14, 11, 0, -14 },
  { 765, 16, 14, 17, 1, -14 },
  { 793, 10, 14, 10, 0, -14 },
  { 811, 10, 14, 10, 0, -14 },
  { 829, 10, 14, 12, 1, -14 },
  { 847, 4, 17, 6, 2, -14 },
  { 856, 6, 14, 6, 0, -14 },
  { 867, 5, 17, 6, 0, -14 },
  { 878, 9, 8, 11, 1, -14 },
  { 887, 8, 1, 8, 0, 2 },
  { 888, 3, 3, 5, 1, -15 },
  { 890, 8, 11, 10, 1, -11 },
  { 901, 8, 15, 12, 2, -15 },
  { 916, 8, 11, 9, 1, -11 },
  { 927, 9, 15, 12, 1, -15 },
  { 944, 9, 11, 11, 1, -11 },
  { 957, 7, 15, 5, 0, -15 },
  { 971, 9, 16, 12, 1, -11 },
  { 989, 8, 15, 11, 2, -15 },
  { 1004, 1, 14, 4, 2, -14 },
  { 1006, 4, 19, 4, -1, -14 },
  { 1016, 7, 15, 9, 2, -15 },
  { 1030, 1, 15, 4, 2, -15 },
  { 1032, 13, 11, 17, 2, -11 },
  { 1050, 8, 11, 11, 2, -11 },
  { 1061, 9, 11, 12, 1, -11 },
  { 1074, 9, 16, 12, 2, -11 },
  { 1092, 9, 16, 12, 1, -11 },
  { 1110, 5, 11, 8, 2, -11 },
  { 1117, 7, 11, 9, 1, -11 },
  { 1127, 6, 13, 6, 0, -13 },
  { 1137, 8, 11, 11, 2, -11 },
  { 1148, 9, 11, 9, 0, -11 },
  { 1161, 13, 11, 14, 0, -11 },
  { 1179, 8, 11, 10, 1, -11 },
  { 1190, 9, 16, 9, 0, -11 },
  { 1208, 7, 11, 9, 1, -11 },
  { 1218, 5, 17, 7, 1, -14 },
  { 1229, 1, 20, 11, 5, -15 },
  { 1232, 5, 17, 7, 1, -14 },
  { 1243, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Thin20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin20pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_THIN20PT7B_H_
