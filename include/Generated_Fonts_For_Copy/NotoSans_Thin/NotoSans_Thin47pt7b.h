#ifndef _NOTOSANS_THIN47PT7B_H_
#define _NOTOSANS_THIN47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x01, 0xF0, 0xC1, 0xE0,
  0xF0, 0x78, 0x34, 0x1A, 0x0D, 0x06, 0x83, 0x41, 0xA0, 0x90, 0x48, 0x24,
  0x10, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30,
  0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x08, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x02,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0xFE, 0x01, 0xC4, 0x7C,
  0x60, 0x81, 0x18, 0x10, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x80, 0x80, 0x18, 0x10, 0x01,
  0x82, 0x00, 0x18, 0x40, 0x00, 0xC8, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x04, 0xC0, 0x00, 0x86, 0x00, 0x10, 0x60, 0x02, 0x06, 0x00, 0x40, 0x60,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0xC0,
  0x10, 0x18, 0x02, 0x02, 0x00, 0x41, 0x98, 0x08, 0x61, 0xFF, 0xF8, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x00,
  0xC0, 0x38, 0xC0, 0x00, 0x80, 0x20, 0x60, 0x01, 0x80, 0x40, 0x30, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x18, 0x08, 0x00, 0x80, 0x18, 0x18,
  0x00, 0x80, 0x18, 0x10, 0x00, 0x80, 0x18, 0x30, 0x00, 0x80, 0x18, 0x20,
  0x00, 0x80, 0x10, 0x40, 0xC0, 0x80, 0x10, 0xC3, 0xF8, 0xC0, 0x10, 0x84,
  0x0C, 0x40, 0x31, 0x8C, 0x04, 0x40, 0x21, 0x08, 0x06, 0x60, 0x63, 0x18,
  0x02, 0x38, 0xC2, 0x10, 0x02, 0x0F, 0x86, 0x10, 0x02, 0x00, 0x04, 0x10,
  0x02, 0x00, 0x08, 0x10, 0x02, 0x00, 0x08, 0x10, 0x03, 0x00, 0x10, 0x10,
  0x02, 0x00, 0x30, 0x10, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x60, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x08,
  0x04, 0x01, 0x00, 0x0C, 0x04, 0x01, 0x00, 0x06, 0x08, 0x02, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10,
  0xE0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xA0, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x18, 0x08, 0x00, 0x13, 0x00, 0x40, 0x02, 0x60,
  0x02, 0x00, 0x24, 0x00, 0x10, 0x06, 0xC0, 0x00, 0x80, 0x48, 0x00, 0x04,
  0x0C, 0x80, 0x00, 0x20, 0x88, 0x00, 0x01, 0x18, 0x80, 0x00, 0x19, 0x08,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xF0, 0x60, 0x00,
  0x19, 0x83, 0x00, 0x06, 0x0C, 0x1C, 0x01, 0xC0, 0x60, 0x7F, 0xF0, 0x03,
  0xFF, 0x55, 0x55, 0x40, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x10,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x20,
  0x60, 0xC0, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0C, 0x04, 0x07, 0x78, 0x41,
  0xC0, 0x74, 0xE0, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x90, 0x00, 0x11,
  0x80, 0x03, 0x08, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x33, 0x22,
  0x26, 0x44, 0x48, 0x80, 0xFF, 0xE0, 0x7C, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38,
  0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x04, 0x10, 0x00, 0x11, 0x80,
  0x00, 0x88, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x80, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x02, 0x40, 0x00,
  0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x42, 0x00, 0x02, 0x18,
  0x00, 0x30, 0x40, 0x01, 0x01, 0x00, 0x10, 0x06, 0x03, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x40, 0x70, 0x34, 0x19, 0x18, 0x4C, 0x16, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x03, 0xF8, 0x01, 0xE0,
  0xE0, 0x30, 0x03, 0x04, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x00,
  0x70, 0x1C, 0x0E, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x90, 0x00, 0x08, 0xF0, 0x01, 0x80,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x04, 0x01, 0x00, 0x06,
  0x00, 0x80, 0x06, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x03,
  0x00, 0x08, 0x03, 0x00, 0x04, 0x01, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x80, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x9F, 0xF0, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x90,
  0x00, 0x18, 0xF0, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0x01, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x1C, 0x03, 0x0F, 0xFC, 0x19,
  0xC0, 0x18, 0x98, 0x00, 0x65, 0x80, 0x01, 0xA8, 0x00, 0x05, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x32, 0x00, 0x01,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x81, 0x80, 0x08, 0x06, 0x01, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78,
  0x38, 0x06, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x02, 0x30, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x40, 0x00, 0x23, 0x00, 0x01, 0x08, 0x00,
  0x08, 0x60, 0x00, 0x81, 0x80, 0x0C, 0x06, 0x01, 0xC0, 0x1C, 0x18, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x70, 0x03, 0x00, 0x60, 0x20, 0x01,
  0x82, 0x00, 0x06, 0x30, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x2C, 0x00, 0x01,
  0x20, 0x00, 0x19, 0x80, 0x00, 0x86, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x3F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x70, 0x06, 0x00, 0xC0, 0x40, 0x01,
  0x06, 0x00, 0x04, 0x20, 0x00, 0x33, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x34, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x78, 0x00, 0x06, 0x40, 0x00, 0x73, 0x00,
  0x06, 0x8C, 0x00, 0x64, 0x18, 0x1C, 0x20, 0x7F, 0x81, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44, 0x48, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0,
  0xF0, 0x78, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x80, 0x01, 0xF8, 0x01, 0x8C, 0x00, 0x78, 0xF0, 0x04, 0x40, 0x06, 0x00,
  0x80, 0x26, 0x00, 0x40, 0x04, 0x01, 0x20, 0x04, 0x00, 0x20, 0x0D, 0x00,
  0x60, 0x01, 0x00, 0x68, 0x02, 0x00, 0x08, 0x01, 0x40, 0x30, 0x00, 0x40,
  0x0E, 0x01, 0x80, 0x02, 0x00, 0x70, 0x08, 0x00, 0x30, 0x07, 0x80, 0x40,
  0x01, 0x80, 0x3C, 0x02, 0x00, 0x0C, 0x01, 0x60, 0x18, 0x00, 0x60, 0x09,
  0x00, 0xC0, 0x03, 0x00, 0x48, 0x02, 0x00, 0x28, 0x06, 0x40, 0x18, 0x01,
  0x40, 0x22, 0x00, 0x40, 0x13, 0x02, 0x18, 0x01, 0xC7, 0x0C, 0x70, 0x40,
  0x07, 0xE0, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x06, 0x00, 0x7F, 0xFF,
  0xC0, 0x08, 0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x08,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00,
  0x1A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x03,
  0x10, 0x01, 0xE0, 0xFF, 0xFC, 0x04, 0x00, 0x1C, 0x20, 0x00, 0x19, 0x00,
  0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x18, 0x80, 0x07, 0x87,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x0F, 0x01, 0x80, 0x01,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x20, 0x00, 0xF0, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x82, 0x00, 0x01, 0x81, 0x00, 0x03,
  0x80, 0x80, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xA0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFA, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x00,
  0xF8, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x01, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xFF,
  0xE0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0xFE, 0x70, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x81, 0x9F, 0xE0, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xA0, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00,
  0x18, 0x10, 0x01, 0x80, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18, 0x01,
  0x01, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x11, 0xE0,
  0x00, 0x99, 0x00, 0x05, 0x84, 0x00, 0x38, 0x30, 0x01, 0x80, 0xC0, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x10, 0x01, 0x80, 0x80, 0x04,
  0x04, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x62, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x02,
  0xD8, 0x00, 0x00, 0x36, 0x40, 0x00, 0x01, 0x33, 0x00, 0x00, 0x09, 0x88,
  0x00, 0x00, 0xCC, 0x60, 0x00, 0x04, 0x61, 0x00, 0x00, 0x63, 0x08, 0x00,
  0x02, 0x18, 0x60, 0x00, 0x10, 0xC1, 0x00, 0x01, 0x86, 0x0C, 0x00, 0x08,
  0x30, 0x20, 0x00, 0xC1, 0x81, 0x00, 0x04, 0x0C, 0x0C, 0x00, 0x20, 0x60,
  0x20, 0x02, 0x03, 0x01, 0x80, 0x10, 0x18, 0x04, 0x01, 0x80, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x04, 0x04, 0x01, 0x80, 0x30, 0x20,
  0x0C, 0x00, 0x83, 0x00, 0x60, 0x04, 0x10, 0x03, 0x00, 0x11, 0x80, 0x18,
  0x00, 0x88, 0x00, 0xC0, 0x06, 0x40, 0x06, 0x00, 0x16, 0x00, 0x30, 0x00,
  0xA0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x84, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x04,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x82, 0x00, 0x1C, 0x40,
  0x00, 0xC8, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x01, 0x90, 0x00, 0xE3, 0xFF,
  0xF0, 0x7F, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x20, 0x00, 0xE1, 0x00, 0x01, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01,
  0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00,
  0x03, 0x10, 0x00, 0x30, 0x80, 0x03, 0x04, 0x00, 0xF0, 0x3F, 0xFC, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x80, 0x40, 0x04, 0x02, 0x00, 0x30, 0x10, 0x00,
  0xC0, 0x80, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x40, 0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x34, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0xE0, 0x3E, 0x18, 0x00, 0x22,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0xC0, 0x03, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x60, 0x00, 0x10,
  0x18, 0x00, 0x18, 0x07, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C,
  0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0x80, 0x08,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x03, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x20, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01,
  0x20, 0x00, 0x68, 0x00, 0x09, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x11,
  0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x21, 0x00, 0x08, 0x40, 0x01, 0x0C,
  0x00, 0x41, 0x00, 0x18, 0x20, 0x02, 0x08, 0x00, 0x81, 0x00, 0x30, 0x40,
  0x04, 0x08, 0x01, 0x03, 0x00, 0x60, 0x60, 0x08, 0x08, 0x03, 0x01, 0x00,
  0x40, 0x40, 0x10, 0x08, 0x06, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x03, 0x01, 0x00, 0x40, 0x40, 0x08, 0x18, 0x02, 0x02, 0x00, 0x40, 0xC0,
  0x18, 0x30, 0x03, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00,
  0x43, 0x00, 0x10, 0x40, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0xC8, 0x00, 0x12,
  0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80,
  0x00, 0x81, 0x00, 0x00, 0x43, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x42, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x80,
  0x01, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x20,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x01, 0x00, 0x80,
  0x01, 0x01, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x20,
  0x00, 0x04, 0x40, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC0, 0x80,
  0x01, 0x01, 0x00, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xC0, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x03, 0xFC, 0x07, 0x01, 0xC1, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x01, 0xFF, 0x07, 0xC0, 0x47, 0x00, 0x13, 0x00, 0x05, 0x80,
  0x01, 0x40, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xD0, 0x00, 0x56, 0x00, 0x24, 0xC0, 0x31, 0x1F, 0xF8, 0x40, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x07, 0xFC, 0x08, 0x60, 0x38, 0x4C, 0x00, 0x62, 0x40,
  0x01, 0x14, 0x00, 0x04, 0xA0, 0x00, 0x26, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x94, 0x00, 0x0C, 0xB0, 0x00,
  0x44, 0x80, 0x04, 0x23, 0x00, 0xC1, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x81,
  0xC0, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x03, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x3F, 0xE1,
  0x0E, 0x03, 0x11, 0x80, 0x09, 0x30, 0x00, 0x52, 0x00, 0x07, 0x60, 0x00,
  0x34, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36,
  0x00, 0x07, 0x20, 0x00, 0x51, 0x00, 0x09, 0x0C, 0x03, 0x10, 0x7F, 0xE1,
  0x03, 0xFC, 0x00, 0x60, 0x30, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x20, 0x00,
  0x46, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x0E,
  0x03, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0x0C, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x07,
  0xFF, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03,
  0xFE, 0x10, 0xE0, 0x31, 0x18, 0x00, 0xD3, 0x00, 0x05, 0x20, 0x00, 0x34,
  0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00,
  0x03, 0x60, 0x00, 0x72, 0x00, 0x05, 0x10, 0x00, 0x90, 0xC0, 0x31, 0x07,
  0xFE, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x64, 0x00, 0x0C,
  0x78, 0x03, 0x80, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x41, 0xFF, 0x08, 0xE0, 0x31,
  0x30, 0x01, 0x2C, 0x00, 0x35, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFC, 0x00, 0x2A, 0xAA, 0xAA,
  0xAA, 0xAA, 0xAA, 0xA0, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0xF8, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x06, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x00,
  0x60, 0x80, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x00,
  0x20, 0x80, 0x08, 0x60, 0x02, 0x24, 0x00, 0x99, 0x80, 0x2C, 0x30, 0x0E,
  0x04, 0x03, 0x00, 0x80, 0x80, 0x30, 0x20, 0x06, 0x08, 0x00, 0x82, 0x00,
  0x10, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x12, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xF0, 0x8C,
  0x0C, 0x18, 0x0C, 0x90, 0x02, 0x30, 0x06, 0xA0, 0x03, 0x60, 0x02, 0xA0,
  0x01, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x83,
  0xFE, 0x11, 0xC0, 0x62, 0x60, 0x02, 0x58, 0x00, 0x6A, 0x00, 0x05, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x03,
  0xFE, 0x00, 0x30, 0x1C, 0x06, 0x00, 0x30, 0x60, 0x00, 0xC2, 0x00, 0x02,
  0x30, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00,
  0x04, 0x80, 0x00, 0x22, 0x00, 0x02, 0x18, 0x00, 0x30, 0x60, 0x03, 0x01,
  0x80, 0x30, 0x03, 0xFE, 0x00, 0x81, 0xFE, 0x04, 0x30, 0x1C, 0x22, 0x00,
  0x31, 0x20, 0x00, 0xCA, 0x00, 0x02, 0x50, 0x00, 0x1B, 0x00, 0x00, 0x58,
  0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0x4A, 0x00, 0x02,
  0x58, 0x00, 0x22, 0x60, 0x03, 0x19, 0x80, 0x70, 0xC3, 0xFE, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x10, 0xE0, 0x31, 0x18, 0x00, 0x93,
  0x00, 0x05, 0x60, 0x00, 0x74, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x52, 0x00, 0x0D, 0x30,
  0x01, 0x91, 0xC0, 0x31, 0x07, 0xFC, 0x10, 0x06, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x83, 0xFC,
  0x60, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x07, 0xFE, 0x0C, 0x01, 0xC8, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0E, 0x00, 0x0D, 0xC0, 0x0C, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xC3, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x80, 0x02, 0x58, 0x00, 0xC9, 0xC0,
  0x71, 0x0F, 0xF8, 0x20, 0x80, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x26,
  0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x00, 0x08,
  0x10, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x40, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10,
  0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x40, 0x02,
  0x80, 0x09, 0x80, 0x13, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x06, 0x20, 0x08, 0x60, 0x10, 0xC0, 0x20, 0x80, 0x41, 0x00, 0x82, 0x03,
  0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x82, 0x01, 0x86, 0x02, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x08, 0x40, 0x11,
  0x00, 0x31, 0x00, 0x44, 0x00, 0x4C, 0x01, 0x90, 0x01, 0x20, 0x02, 0xC0,
  0x04, 0x80, 0x0A, 0x00, 0x0A, 0x00, 0x28, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x32, 0x00, 0x06, 0x30, 0x00,
  0xC1, 0x80, 0x08, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x20,
  0x40, 0x01, 0x0C, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x98, 0x00, 0x10, 0x80, 0x03, 0x04, 0x00,
  0x20, 0x60, 0x04, 0x02, 0x00, 0xC0, 0x10, 0x18, 0x01, 0x81, 0x00, 0x0C,
  0x20, 0x00, 0x46, 0x00, 0x02, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0x40, 0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30,
  0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00,
  0xC0, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x00, 0x90,
  0x00, 0x09, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x08, 0x07, 0xC0, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x0F, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x07, 0x80, 0x7C,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x01, 0x80, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00,
  0x70, 0x1C, 0x07, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 34, 10, 4, -34 },
  { 10, 9, 13, 15, 3, -34 },
  { 25, 28, 34, 30, 1, -34 },
  { 144, 19, 39, 27, 3, -36 },
  { 237, 32, 34, 37, 3, -34 },
  { 373, 28, 34, 33, 3, -34 },
  { 492, 2, 13, 8, 3, -34 },
  { 496, 8, 41, 12, 2, -34 },
  { 537, 8, 41, 12, 2, -34 },
  { 578, 20, 19, 26, 3, -36 },
  { 626, 21, 21, 27, 3, -27 },
  { 682, 4, 11, 9, 2, -5 },
  { 688, 11, 1, 15, 2, -13 },
  { 690, 2, 3, 10, 4, -3 },
  { 691, 14, 34, 15, 1, -34 },
  { 751, 21, 34, 27, 3, -34 },
  { 841, 10, 34, 27, 5, -34 },
  { 884, 20, 34, 27, 3, -34 },
  { 969, 21, 34, 27, 2, -34 },
  { 1059, 25, 34, 27, 1, -34 },
  { 1166, 21, 34, 27, 3, -34 },
  { 1256, 21, 34, 27, 3, -34 },
  { 1346, 21, 34, 27, 3, -34 },
  { 1436, 21, 34, 27, 3, -34 },
  { 1526, 21, 35, 27, 3, -34 },
  { 1618, 2, 25, 10, 4, -25 },
  { 1625, 4, 31, 10, 2, -25 },
  { 1641, 21, 22, 27, 3, -28 },
  { 1699, 21, 11, 27, 3, -22 },
  { 1728, 21, 22, 27, 3, -28 },
  { 1786, 16, 34, 19, 2, -34 },
  { 1854, 37, 38, 41, 2, -33 },
  { 2030, 27, 34, 27, 0, -34 },
  { 2145, 21, 34, 29, 5, -34 },
  { 2235, 24, 34, 29, 3, -34 },
  { 2337, 25, 34, 33, 5, -34 },
  { 2444, 18, 34, 26, 5, -34 },
  { 2521, 18, 34, 23, 5, -34 },
  { 2598, 27, 34, 34, 3, -34 },
  { 2713, 23, 34, 33, 5, -34 },
  { 2811, 7, 34, 13, 3, -34 },
  { 2841, 11, 42, 11, -5, -34 },
  { 2899, 21, 34, 26, 5, -34 },
  { 2989, 18, 34, 24, 5, -34 },
  { 3066, 29, 34, 39, 5, -34 },
  { 3190, 23, 34, 33, 5, -34 },
  { 3288, 29, 34, 35, 3, -34 },
  { 3412, 19, 34, 27, 5, -34 },
  { 3493, 29, 42, 35, 3, -34 },
  { 3646, 21, 34, 27, 5, -34 },
  { 3736, 20, 34, 26, 3, -34 },
  { 3821, 24, 34, 24, 0, -34 },
  { 3923, 25, 34, 33, 4, -34 },
  { 4030, 26, 34, 26, 0, -34 },
  { 4141, 37, 34, 41, 2, -34 },
  { 4299, 24, 34, 24, 0, -34 },
  { 4401, 24, 34, 24, 0, -34 },
  { 4503, 23, 34, 27, 2, -34 },
  { 4601, 10, 41, 15, 4, -34 },
  { 4653, 14, 34, 15, 1, -34 },
  { 4713, 10, 41, 15, 1, -34 },
  { 4765, 23, 21, 27, 2, -34 },
  { 4826, 18, 1, 18, 0, 4 },
  { 4829, 8, 8, 12, 2, -36 },
  { 4837, 18, 25, 24, 2, -25 },
  { 4894, 21, 36, 27, 4, -36 },
  { 4989, 18, 25, 22, 3, -25 },
  { 5046, 20, 36, 27, 3, -36 },
  { 5136, 20, 25, 25, 3, -25 },
  { 5199, 15, 36, 13, 1, -36 },
  { 5267, 20, 36, 27, 3, -25 },
  { 5357, 19, 36, 27, 4, -36 },
  { 5443, 2, 34, 10, 4, -34 },
  { 5452, 8, 45, 10, -2, -34 },
  { 5497, 18, 36, 21, 4, -36 },
  { 5578, 2, 36, 10, 4, -36 },
  { 5587, 32, 25, 40, 4, -25 },
  { 5687, 19, 25, 27, 4, -25 },
  { 5747, 21, 25, 27, 3, -25 },
  { 5813, 21, 36, 27, 4, -25 },
  { 5908, 20, 36, 27, 3, -25 },
  { 5998, 13, 25, 18, 4, -25 },
  { 6039, 17, 25, 22, 2, -25 },
  { 6093, 14, 31, 15, 0, -31 },
  { 6148, 19, 25, 27, 4, -25 },
  { 6208, 20, 25, 20, 0, -25 },
  { 6271, 30, 25, 32, 1, -25 },
  { 6365, 20, 25, 23, 1, -25 },
  { 6428, 20, 36, 20, 0, -25 },
  { 6518, 18, 25, 21, 2, -25 },
  { 6575, 13, 41, 16, 1, -34 },
  { 6642, 1, 48, 25, 12, -36 },
  { 6648, 13, 41, 16, 2, -34 },
  { 6715, 21, 4, 27, 3, -19 },
};

const GFXfont NotoSans_Thin47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin47pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_THIN47PT7B_H_
