#ifndef _NOTOSANS_THIN50PT7B_H_
#define _NOTOSANS_THIN50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x0B, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10,
  0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x01,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x02, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x0E, 0x23, 0xE1, 0x82, 0x02, 0x20, 0x20,
  0x06, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0xC0, 0x20, 0x0C, 0x02,
  0x00, 0xC0, 0x20, 0x0C, 0x02, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x30,
  0x20, 0x00, 0xC2, 0x00, 0x07, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x02, 0xF0, 0x00, 0x21, 0x80, 0x02, 0x0C, 0x00, 0x20, 0x20, 0x02, 0x03,
  0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20,
  0x10, 0x02, 0x01, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20, 0xCE, 0x02,
  0x18, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x06, 0x18, 0x00, 0x18, 0x03, 0x03,
  0x00, 0x04, 0x01, 0x80, 0x40, 0x03, 0x00, 0x40, 0x18, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x08, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x20, 0x03, 0x01, 0x00, 0x08, 0x00, 0xC0, 0xC0,
  0x02, 0x00, 0x30, 0x20, 0x00, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x03, 0x04,
  0x00, 0x0C, 0x00, 0x83, 0x07, 0x83, 0x00, 0x20, 0x87, 0x38, 0x40, 0x08,
  0x43, 0x03, 0x10, 0x06, 0x31, 0x80, 0x46, 0x01, 0x08, 0x40, 0x18, 0x80,
  0xC6, 0x10, 0x02, 0x18, 0x61, 0x0C, 0x00, 0x83, 0xF0, 0xC3, 0x00, 0x20,
  0x00, 0x20, 0x80, 0x0C, 0x00, 0x18, 0x20, 0x03, 0x00, 0x04, 0x08, 0x00,
  0xC0, 0x02, 0x02, 0x00, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x40, 0x20,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x20,
  0x00, 0x80, 0xC0, 0x18, 0x00, 0x30, 0x60, 0x0C, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x17, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x08, 0x80,
  0x0C, 0x00, 0x26, 0x00, 0x18, 0x01, 0x90, 0x00, 0x30, 0x04, 0xC0, 0x00,
  0x60, 0x33, 0x00, 0x00, 0xC0, 0x8C, 0x00, 0x01, 0x86, 0x30, 0x00, 0x03,
  0x10, 0xC0, 0x00, 0x06, 0x83, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x01, 0xB0, 0x20, 0x00, 0x0C, 0x60, 0x60, 0x00, 0xE0, 0xC0,
  0xE0, 0x0E, 0x01, 0x80, 0xFF, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18,
  0x04, 0x03, 0x78, 0x20, 0xF0, 0x79, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x60,
  0x00, 0x05, 0x00, 0x00, 0x44, 0x00, 0x06, 0x10, 0x00, 0x20, 0xC0, 0x02,
  0x02, 0x00, 0x30, 0x08, 0x03, 0x00, 0x60, 0x10, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x13, 0x33, 0x22, 0x26, 0x44, 0xC8, 0xFF,
  0xF0, 0x5F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x06, 0x00,
  0xC0, 0x0C, 0x02, 0x00, 0x08, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x98, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60,
  0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x20, 0x30, 0x01, 0x00, 0x70, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x1C, 0x06, 0x83, 0x90, 0xC2, 0x30, 0x5C, 0x0E, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0xFC, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x08, 0x18, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x1E, 0x03, 0x80, 0xE0,
  0x01, 0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x19, 0x00, 0x00, 0x61, 0xE0, 0x03, 0x00, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x08, 0x00, 0x02, 0x01, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00,
  0x10, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x80, 0x01, 0x00, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x0B, 0xFF, 0xC0,
  0x70, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x64, 0x00, 0x06, 0x38,
  0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xC0, 0x20, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x3F, 0xC0, 0x21, 0xE1, 0xE0, 0x4E, 0x00, 0x61, 0xB0, 0x00, 0x23,
  0x40, 0x00, 0x27, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0,
  0x00, 0x01, 0x20, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x08, 0x00, 0x10, 0x18, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x30, 0x01, 0x80, 0x60, 0x18, 0x00, 0xE1, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x30, 0x03, 0x80, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x03, 0x40, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x20, 0x00, 0x10, 0x60, 0x00,
  0x80, 0xE0, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x00,
  0x38, 0x0C, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x30, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x1D, 0x80, 0x00, 0xD2, 0x00,
  0x06, 0x46, 0x00, 0x31, 0x0E, 0x03, 0x8C, 0x0F, 0xF8, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x5F, 0x80, 0x11, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x18, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x0E, 0x20, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x62, 0x00, 0x0F, 0xFC, 0x00,
  0x98, 0x00, 0xE0, 0x18, 0x03, 0x40, 0x06, 0x00, 0x20, 0x0D, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0x80, 0x06, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01,
  0x80, 0x10, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x02, 0x00,
  0x06, 0x00, 0x60, 0x08, 0x00, 0x10, 0x01, 0x80, 0x20, 0x00, 0x40, 0x06,
  0x00, 0x80, 0x01, 0x00, 0x18, 0x02, 0x00, 0x04, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x02, 0x80, 0x30, 0x00, 0xC0, 0x0A, 0x00, 0x40, 0x03, 0x80, 0x6C,
  0x01, 0x80, 0x12, 0x01, 0x30, 0x03, 0x01, 0x8C, 0x08, 0x40, 0x07, 0xFC,
  0x1F, 0xC1, 0x80, 0x03, 0x80, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x10, 0x01, 0x00, 0x00, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x02, 0x00,
  0x03, 0x84, 0x00, 0x01, 0x88, 0x00, 0x01, 0x90, 0x00, 0x01, 0x20, 0x00,
  0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x0C,
  0x40, 0x00, 0x30, 0x80, 0x1F, 0x81, 0xFF, 0xFE, 0x02, 0x00, 0x03, 0x84,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0xE2, 0x00, 0x0F, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0xF0, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x08, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x38, 0x20, 0x00, 0x38, 0x08, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFA, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x07,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x3C, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xCF, 0xF8, 0x3C, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x40, 0x40, 0x01, 0x00, 0x80, 0x04, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x41, 0x80, 0x00, 0x85, 0x80, 0x01, 0x11, 0x00, 0x02, 0x43,
  0x00, 0x05, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x06, 0x00, 0x80, 0x06, 0x01, 0x00, 0x04, 0x02, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x40, 0x00, 0x18, 0x80, 0x00, 0x11, 0x00, 0x00, 0x32, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xA0, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x0F, 0x90, 0x00, 0x00,
  0x0B, 0x90, 0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x1B, 0x88, 0x00, 0x00,
  0x13, 0x8C, 0x00, 0x00, 0x33, 0x84, 0x00, 0x00, 0x23, 0x84, 0x00, 0x00,
  0x63, 0x86, 0x00, 0x00, 0x43, 0x82, 0x00, 0x00, 0x43, 0x83, 0x00, 0x00,
  0xC3, 0x81, 0x00, 0x00, 0x83, 0x81, 0x00, 0x01, 0x83, 0x81, 0x80, 0x01,
  0x03, 0x80, 0x80, 0x01, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x40, 0x02,
  0x03, 0x80, 0x60, 0x06, 0x03, 0x80, 0x60, 0x04, 0x03, 0x80, 0x20, 0x04,
  0x03, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x10, 0x08, 0x03, 0x80, 0x18, 0x18,
  0x03, 0x80, 0x08, 0x10, 0x03, 0x80, 0x08, 0x30, 0x03, 0x80, 0x0C, 0x20,
  0x03, 0x80, 0x04, 0x20, 0x03, 0x80, 0x06, 0x60, 0x03, 0x80, 0x02, 0x40,
  0x03, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0x20, 0x00, 0x07, 0x18, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x08, 0x00, 0x1C, 0x06, 0x00,
  0x0E, 0x01, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00,
  0x18, 0x0E, 0x00, 0x04, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x20, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0x1C,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0x71, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x64, 0x00,
  0x06, 0x20, 0x00, 0xE1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x07, 0x04, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x41, 0x00, 0x03, 0x02, 0x00, 0x3C, 0x07, 0xFF, 0xC0, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x80, 0x20, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x03,
  0x01, 0x00, 0x02, 0x02, 0x00, 0x06, 0x04, 0x00, 0x04, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x40, 0x00, 0x18, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x34, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x80,
  0x78, 0x07, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x38, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x07, 0x00, 0x03, 0x00, 0x70, 0x03, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x04,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x40, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x06,
  0x40, 0x00, 0x2C, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x04, 0x20, 0x00,
  0x44, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00,
  0x08, 0x30, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0x82, 0x00, 0x18, 0x10,
  0x00, 0x83, 0x00, 0x18, 0x18, 0x01, 0x81, 0x00, 0x10, 0x08, 0x01, 0x01,
  0x00, 0x10, 0x08, 0x01, 0x01, 0x80, 0x30, 0x08, 0x01, 0x01, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x80, 0x60, 0x04, 0x02,
  0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x40, 0x40, 0x06, 0x06, 0x00, 0x40,
  0x40, 0x02, 0x04, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x03,
  0x0C, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00,
  0x31, 0x80, 0x01, 0x08, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x11, 0x00,
  0x00, 0x90, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x1B, 0x00, 0x00, 0xB0,
  0x00, 0x0A, 0x00, 0x00, 0xF0, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x01, 0x88, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x60, 0x00, 0x18,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x08, 0x04, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0x18, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x18, 0x03, 0x00, 0x02,
  0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x30, 0x00, 0x02, 0x18, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x20, 0x60, 0x00, 0x30, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x18,
  0x02, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x10, 0x06,
  0x00, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x63, 0x00, 0x00, 0x41, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x80, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x18, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0xFC, 0x01, 0xF9, 0xE0, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x01, 0xFE, 0x07,
  0xF0, 0x43, 0x80, 0x08, 0xC0, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x3B, 0x00,
  0x05, 0x60, 0x01, 0x27, 0x00, 0xC4, 0x3F, 0xF0, 0x80, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x3F, 0x80, 0xC3, 0xC3, 0x83, 0x38,
  0x03, 0x8D, 0x80, 0x02, 0x34, 0x00, 0x04, 0xF0, 0x00, 0x1B, 0x80, 0x00,
  0x2E, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xB8, 0x00, 0x02, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0x4D, 0x00, 0x02, 0x36,
  0x00, 0x18, 0xCE, 0x01, 0x83, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3E, 0x3C, 0x1C, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x0C, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x3F, 0x83, 0x03, 0xC7, 0x8C, 0x30, 0x03, 0x31, 0x80, 0x06, 0xCC,
  0x00, 0x0F, 0x20, 0x00, 0x1D, 0x80, 0x00, 0x74, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x60, 0x00,
  0x1C, 0x80, 0x00, 0x53, 0x00, 0x02, 0x46, 0x00, 0x19, 0x0E, 0x01, 0x84,
  0x0F, 0xFC, 0x10, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x78, 0x03,
  0x80, 0x30, 0x30, 0x00, 0xC1, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x10,
  0x30, 0x03, 0x80, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x01, 0x81,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0x1E, 0x30, 0xC0, 0x0C, 0xC6, 0x00, 0x0B, 0x30,
  0x00, 0x3C, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD0, 0x00, 0x03, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x1D, 0x80, 0x00,
  0x72, 0x00, 0x03, 0xCC, 0x00, 0x0B, 0x18, 0x00, 0x6C, 0x38, 0x06, 0x30,
  0x3F, 0xF0, 0xC0, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0xE0, 0xF8, 0x1E, 0x00, 0x7F, 0xE0, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x0F, 0xE0, 0xC3, 0xC7, 0x8C, 0xC0, 0x0C, 0xD8,
  0x00, 0x6D, 0x00, 0x02, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x60, 0x01, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC8, 0x63,
  0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00,
  0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC5, 0x80,
  0x19, 0x18, 0x03, 0x41, 0x00, 0x78, 0x10, 0x0E, 0x03, 0x01, 0x80, 0x30,
  0x30, 0x02, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x04,
  0x60, 0x00, 0x4C, 0x00, 0x0D, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x18, 0xF1, 0xC0, 0xF1, 0xC3, 0x30, 0x0C,
  0x30, 0x0E, 0x68, 0x00, 0xCC, 0x00, 0x4F, 0x00, 0x0B, 0x00, 0x0D, 0xC0,
  0x01, 0xC0, 0x00, 0xB0, 0x00, 0x18, 0x00, 0x16, 0x00, 0x02, 0x00, 0x02,
  0xC0, 0x00, 0x40, 0x00, 0x58, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0x01, 0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x07, 0x80, 0x00,
  0x80, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0,
  0x00, 0x40, 0x00, 0x78, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01,
  0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x80,
  0x00, 0xF0, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x00,
  0x40, 0x00, 0x78, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xFE, 0x0C, 0x3C, 0x78, 0xCC, 0x00, 0xCD, 0x80, 0x06, 0xD0, 0x00,
  0x2E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x07,
  0x8F, 0x00, 0x38, 0x03, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00,
  0x03, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x08, 0x00, 0x18, 0x08, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x04, 0x3C, 0x78, 0x23, 0x00,
  0x71, 0x20, 0x00, 0xCA, 0x00, 0x02, 0x70, 0x00, 0x1B, 0x00, 0x00, 0x58,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0x60, 0x00, 0x1B, 0x80, 0x00, 0x96, 0x00, 0x0C, 0x98, 0x00, 0xC4, 0x60,
  0x1C, 0x21, 0xFF, 0x81, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1E, 0x1E, 0x30, 0xC0, 0x0C, 0xC6, 0x00, 0x1B, 0x30,
  0x00, 0x3C, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x1D, 0x80, 0x00,
  0x76, 0x00, 0x03, 0xCC, 0x00, 0x1B, 0x18, 0x00, 0xCC, 0x30, 0x06, 0x30,
  0x7F, 0xE0, 0xC0, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x03, 0xF4, 0x79, 0xE6, 0x01, 0x60, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x03, 0xFC, 0x01, 0xE3,
  0xF8, 0xE0, 0x03, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x80, 0x01, 0x9C, 0x00, 0x60, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x7F, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x40, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x34,
  0x00, 0x05, 0x60, 0x00, 0xD3, 0x00, 0x19, 0x18, 0x07, 0x10, 0xFF, 0xC1,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x64, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x10, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0x88,
  0x00, 0x03, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x03, 0x40, 0x01, 0x40, 0x02, 0x60, 0x03, 0x60, 0x02, 0x60,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x06, 0x30, 0x04, 0x30,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x18, 0x0C, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x0C, 0x18, 0x08,
  0x10, 0x04, 0x18, 0x0C, 0x10, 0x04, 0x10, 0x04, 0x30, 0x06, 0x10, 0x04,
  0x20, 0x02, 0x30, 0x06, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x20, 0x02,
  0x40, 0x03, 0x20, 0x02, 0x40, 0x01, 0x60, 0x03, 0xC0, 0x01, 0x40, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x19, 0x80, 0x01, 0x84, 0x00, 0x18, 0x10, 0x01, 0x80, 0xC0, 0x08,
  0x03, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x86, 0x00, 0x04,
  0x60, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x20, 0x00, 0x11, 0x80, 0x01, 0x86, 0x00, 0x18, 0x10, 0x00, 0x80,
  0xC0, 0x08, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x86,
  0x00, 0x06, 0x60, 0x00, 0x16, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x64, 0x00, 0x01, 0x18, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00,
  0x81, 0x00, 0x06, 0x04, 0x00, 0x10, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20,
  0x30, 0x00, 0x80, 0x80, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x18, 0x40,
  0x00, 0x23, 0x00, 0x00, 0x88, 0x00, 0x03, 0x20, 0x00, 0x05, 0x80, 0x00,
  0x14, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x8C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0C, 0x01, 0xF0, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x03, 0xE0, 0x00, 0xC0,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x38, 0x00,
  0x1F, 0x00, 0x00, 0xE3, 0xC0, 0x07, 0x00, 0xE0, 0x34, 0x00, 0x7F, 0xC0,
  0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 8, 13, 16, 4, -36 },
  { 28, 30, 36, 32, 1, -36 },
  { 163, 20, 41, 29, 3, -38 },
  { 266, 34, 37, 40, 3, -36 },
  { 424, 30, 37, 35, 3, -36 },
  { 563, 1, 13, 9, 4, -36 },
  { 565, 9, 44, 13, 2, -36 },
  { 615, 9, 44, 13, 2, -36 },
  { 665, 21, 20, 28, 3, -38 },
  { 718, 23, 23, 29, 3, -29 },
  { 785, 4, 12, 9, 2, -6 },
  { 791, 12, 1, 16, 2, -14 },
  { 793, 3, 3, 11, 4, -3 },
  { 795, 14, 36, 16, 1, -36 },
  { 858, 22, 37, 29, 3, -36 },
  { 960, 11, 36, 29, 5, -36 },
  { 1010, 22, 36, 29, 3, -36 },
  { 1109, 23, 37, 29, 2, -36 },
  { 1216, 27, 36, 29, 1, -36 },
  { 1338, 21, 37, 29, 4, -36 },
  { 1436, 23, 37, 29, 3, -36 },
  { 1543, 23, 36, 29, 3, -36 },
  { 1647, 22, 37, 29, 3, -36 },
  { 1749, 22, 37, 29, 3, -36 },
  { 1851, 3, 27, 11, 4, -27 },
  { 1862, 5, 33, 11, 2, -27 },
  { 1883, 23, 22, 29, 3, -29 },
  { 1947, 23, 11, 29, 3, -23 },
  { 1979, 23, 22, 29, 3, -29 },
  { 2043, 17, 36, 21, 2, -36 },
  { 2120, 38, 40, 44, 3, -35 },
  { 2310, 29, 36, 29, 0, -36 },
  { 2441, 23, 36, 31, 5, -36 },
  { 2545, 26, 37, 31, 3, -36 },
  { 2666, 26, 36, 35, 5, -36 },
  { 2783, 19, 36, 28, 5, -36 },
  { 2869, 19, 36, 25, 5, -36 },
  { 2955, 29, 37, 36, 3, -36 },
  { 3090, 25, 36, 35, 5, -36 },
  { 3203, 8, 36, 14, 3, -36 },
  { 3239, 12, 45, 12, -5, -36 },
  { 3307, 23, 36, 28, 5, -36 },
  { 3411, 19, 36, 25, 5, -36 },
  { 3497, 32, 36, 42, 5, -36 },
  { 3641, 25, 36, 35, 5, -36 },
  { 3754, 32, 37, 38, 3, -36 },
  { 3902, 21, 36, 29, 5, -36 },
  { 3997, 32, 45, 38, 3, -36 },
  { 4177, 23, 36, 29, 5, -36 },
  { 4281, 21, 37, 27, 3, -36 },
  { 4379, 25, 36, 25, 0, -36 },
  { 4492, 26, 37, 36, 5, -36 },
  { 4613, 28, 36, 28, 0, -36 },
  { 4739, 40, 36, 43, 2, -36 },
  { 4919, 26, 36, 25, 0, -36 },
  { 5036, 25, 36, 25, 0, -36 },
  { 5149, 25, 36, 29, 2, -36 },
  { 5262, 10, 44, 16, 4, -36 },
  { 5317, 14, 36, 16, 1, -36 },
  { 5380, 10, 44, 16, 1, -36 },
  { 5435, 24, 22, 29, 2, -36 },
  { 5501, 20, 1, 20, 0, 5 },
  { 5504, 8, 8, 12, 2, -38 },
  { 5512, 19, 28, 26, 2, -27 },
  { 5579, 22, 39, 29, 4, -38 },
  { 5687, 19, 28, 24, 3, -27 },
  { 5754, 22, 39, 29, 3, -38 },
  { 5862, 21, 28, 27, 3, -27 },
  { 5936, 16, 38, 14, 1, -38 },
  { 6012, 22, 39, 29, 3, -27 },
  { 6120, 20, 38, 29, 4, -38 },
  { 6215, 3, 36, 10, 4, -36 },
  { 6229, 10, 48, 10, -3, -36 },
  { 6289, 19, 38, 23, 4, -38 },
  { 6380, 1, 38, 10, 5, -38 },
  { 6385, 35, 27, 43, 4, -27 },
  { 6504, 20, 27, 29, 4, -27 },
  { 6572, 23, 28, 29, 3, -27 },
  { 6653, 21, 39, 29, 5, -27 },
  { 6756, 22, 39, 29, 3, -27 },
  { 6864, 13, 27, 19, 5, -27 },
  { 6908, 19, 28, 23, 2, -27 },
  { 6975, 15, 34, 16, 0, -33 },
  { 7039, 20, 27, 29, 4, -26 },
  { 7107, 22, 26, 22, 0, -26 },
  { 7179, 32, 26, 34, 1, -26 },
  { 7283, 21, 26, 24, 1, -26 },
  { 7352, 22, 38, 21, 0, -26 },
  { 7457, 19, 26, 23, 2, -26 },
  { 7519, 14, 44, 17, 1, -36 },
  { 7596, 1, 51, 27, 13, -38 },
  { 7603, 14, 44, 17, 2, -36 },
  { 7680, 23, 5, 29, 3, -20 },
};

const GFXfont NotoSans_Thin50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin50pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_THIN50PT7B_H_
