#ifndef _NOTOSANS_THIN56PT7B_H_
#define _NOTOSANS_THIN56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x64, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x01, 0xBF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x04, 0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x40, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x20, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0xC3, 0xE3,
  0x83, 0x01, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x08, 0x03,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x37, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x07, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x20, 0x0C, 0x1C, 0xF8, 0x31, 0xC0,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x01,
  0xC1, 0x80, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x30, 0x04, 0x00,
  0x08, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x60, 0x03, 0x00, 0x08, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x02, 0x06, 0x02, 0x01, 0x00,
  0x08, 0x30, 0x7F, 0x04, 0x00, 0x20, 0x83, 0x06, 0x18, 0x01, 0x86, 0x18,
  0x0C, 0x60, 0x06, 0x10, 0xC0, 0x18, 0xC0, 0x30, 0xC2, 0x00, 0x63, 0x00,
  0xC2, 0x08, 0x00, 0x86, 0x0E, 0x18, 0x60, 0x03, 0x0F, 0xF0, 0xC1, 0x80,
  0x0C, 0x04, 0x03, 0x04, 0x00, 0x30, 0x00, 0x18, 0x10, 0x00, 0x40, 0x00,
  0x40, 0x40, 0x01, 0x00, 0x03, 0x01, 0x00, 0x04, 0x00, 0x08, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x10, 0x00, 0x40, 0x01, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x06, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x02, 0x20, 0x01, 0x80, 0x03, 0x30, 0x00, 0x60, 0x01, 0xB0, 0x00, 0x18,
  0x00, 0x98, 0x00, 0x06, 0x00, 0xC8, 0x00, 0x01, 0x80, 0x44, 0x00, 0x00,
  0x60, 0x62, 0x00, 0x00, 0x18, 0x21, 0x00, 0x00, 0x06, 0x30, 0x80, 0x00,
  0x01, 0xB0, 0x40, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x1E, 0x06, 0x00, 0x00, 0x31, 0x81, 0x80, 0x00, 0x30, 0x60, 0x60,
  0x00, 0x70, 0x18, 0x1C, 0x00, 0xE0, 0x06, 0x03, 0xFF, 0xC0, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xA0, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x40, 0x08, 0x01,
  0xF8, 0x08, 0x0F, 0x1E, 0x08, 0x78, 0x01, 0xCB, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x22, 0x00, 0x00, 0x43, 0x00,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6,
  0x23, 0x18, 0x84, 0x60, 0xFF, 0xFF, 0xFF, 0xF0, 0xDF, 0x80, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00,
  0x20, 0x60, 0x00, 0x18, 0x20, 0x00, 0x04, 0x30, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x40, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x07, 0x01, 0xB0, 0x33,
  0x0E, 0x31, 0xC3, 0x30, 0x3E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x38, 0x03, 0x00, 0x06, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0x3C,
  0x07, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xE1, 0xF0, 0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x00,
  0x58, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFC,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x21, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x70, 0x78, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0xFF, 0xF0, 0x21, 0xE0, 0x1C, 0x11,
  0x80, 0x03, 0x09, 0x80, 0x00, 0x45, 0x80, 0x00, 0x32, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x30, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x03, 0x81, 0xC0, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xEF,
  0x00, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xC0,
  0x38, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x52, 0x00, 0x00, 0x69, 0x80, 0x00,
  0x6C, 0x60, 0x00, 0xE6, 0x1C, 0x01, 0xC3, 0x03, 0xFF, 0xC1, 0x80, 0x0E,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x40, 0x0F, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x6F, 0xC0, 0x18, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x61,
  0x84, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0x83, 0xC0, 0x3C, 0x40, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x01, 0xFF, 0xC0, 0x0C, 0x60,
  0x00, 0xE0, 0x18, 0x00, 0x98, 0x00, 0x70, 0x01, 0x00, 0x1B, 0x00, 0x18,
  0x00, 0x20, 0x03, 0x40, 0x02, 0x00, 0x04, 0x00, 0x68, 0x00, 0xC0, 0x00,
  0x80, 0x07, 0x00, 0x10, 0x00, 0x10, 0x00, 0xE0, 0x06, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x80, 0x00, 0x40, 0x03, 0x80, 0x10, 0x00, 0x08, 0x00, 0x60,
  0x02, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x20, 0x00,
  0x30, 0x01, 0xE0, 0x04, 0x00, 0x06, 0x00, 0x2C, 0x00, 0xC0, 0x01, 0x40,
  0x0D, 0x80, 0x18, 0x00, 0x28, 0x01, 0x10, 0x01, 0x80, 0x09, 0x80, 0x62,
  0x00, 0x18, 0x06, 0x10, 0x18, 0x60, 0x01, 0xE7, 0x83, 0xDE, 0x0C, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x40, 0x0F, 0xF0, 0x20, 0x00, 0x0E, 0x10, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40, 0x00, 0x38, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x08, 0x00, 0x03, 0x84, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xC4, 0x00, 0x01, 0xC2,
  0x00, 0x1F, 0x81, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x20, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x20, 0x00,
  0x1E, 0x01, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x70, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x38, 0x02, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFA, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x31, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x68, 0x0C, 0xFF, 0x87, 0xE0, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x03, 0x10, 0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x01, 0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x03, 0x00, 0x08, 0x03, 0x00, 0x04, 0x03,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0x83, 0x00, 0x00, 0x43,
  0xC0, 0x00, 0x23, 0x30, 0x00, 0x13, 0x18, 0x00, 0x0B, 0x06, 0x00, 0x05,
  0x01, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x03, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x18,
  0x04, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x02, 0xD8, 0x00, 0x00,
  0x00, 0xDB, 0x00, 0x00, 0x00, 0x1B, 0x20, 0x00, 0x00, 0x02, 0x66, 0x00,
  0x00, 0x00, 0xCC, 0x40, 0x00, 0x00, 0x11, 0x8C, 0x00, 0x00, 0x06, 0x31,
  0x80, 0x00, 0x00, 0x86, 0x10, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x20, 0x00, 0x00, 0x83, 0x06, 0x00, 0x00, 0x30, 0x60, 0xC0, 0x00,
  0x04, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x81, 0x80, 0x00, 0x30, 0x30, 0x10,
  0x00, 0x04, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x20, 0x18,
  0x04, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x08, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0x08, 0x08, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x00, 0x30, 0x40, 0x01, 0x80, 0x02, 0x18, 0x00, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x00, 0x04, 0x40, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0x00, 0x1A,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0x00, 0x3F, 0x02, 0x00, 0x03, 0x84, 0x00, 0x01, 0x88, 0x00, 0x01,
  0x90, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x03, 0x88, 0x00, 0x1C, 0x10, 0x1F,
  0xF0, 0x3F, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFE, 0x00, 0x40, 0x1F, 0xE0, 0x20, 0x00, 0x3C, 0x10, 0x00,
  0x07, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x62, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x90,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x10, 0x00, 0x1C, 0x08, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00,
  0x60, 0x10, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x03, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xF8,
  0x07, 0x80, 0x1E, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xB0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x01,
  0xC0, 0x00, 0x04, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x10, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x84, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x86, 0x00, 0x02, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10,
  0x20, 0x00, 0x60, 0x80, 0x01, 0x81, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x04,
  0x00, 0x10, 0x30, 0x00, 0x40, 0x20, 0x00, 0x81, 0x80, 0x06, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x00, 0x20, 0x02,
  0x01, 0x80, 0x08, 0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x20, 0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x01, 0x00, 0x40, 0x0C,
  0x03, 0x00, 0x08, 0x06, 0x00, 0x20, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x80, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x61, 0x80, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x08, 0x60, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x00, 0x44,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x02, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x06, 0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x20, 0x18, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x30, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x20,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x7C, 0x1E, 0x0E,
  0x00, 0x38, 0x40, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0xF0, 0x01,
  0x1C, 0x00, 0x09, 0x80, 0x00, 0x58, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x2E,
  0x00, 0x03, 0x70, 0x00, 0x32, 0xC0, 0x03, 0x13, 0x80, 0x70, 0x87, 0xFE,
  0x04, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x83, 0xC1,
  0xE0, 0x86, 0x00, 0x30, 0x9C, 0x00, 0x18, 0x98, 0x00, 0x0C, 0xB0, 0x00,
  0x04, 0xA0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xE0, 0x00, 0x06, 0xA0, 0x00, 0x04, 0xB0, 0x00,
  0x0C, 0x98, 0x00, 0x18, 0x8C, 0x00, 0x30, 0x87, 0x00, 0xE0, 0x83, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0xF0, 0x38, 0x00,
  0x41, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x1C,
  0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x03,
  0xFC, 0x0C, 0x07, 0x83, 0x86, 0x0E, 0x00, 0x73, 0x0C, 0x00, 0x09, 0x8C,
  0x00, 0x06, 0xC4, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x72, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x72, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x16, 0x30, 0x00, 0x1B, 0x0C,
  0x00, 0x19, 0x83, 0xC0, 0x38, 0xC0, 0x7F, 0xF0, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xE1, 0xE0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x02,
  0x03, 0x80, 0x1E, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xF0, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xC1, 0x81, 0xF0, 0xF8, 0xC1, 0xC0, 0x06, 0x61, 0x80, 0x01, 0xB1, 0x80,
  0x00, 0x58, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0x40, 0x00,
  0x07, 0x30, 0x00, 0x07, 0x88, 0x00, 0x02, 0xC6, 0x00, 0x03, 0x61, 0xC0,
  0x03, 0x30, 0x78, 0x07, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x18, 0x1F, 0x00, 0x38, 0x01, 0xFF, 0xF0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x03, 0xFE, 0x0C, 0x3C, 0x1E, 0x33, 0x80, 0x1C, 0x98, 0x00, 0x1A,
  0x40, 0x00, 0x6A, 0x00, 0x00, 0xE8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40,
  0xFD, 0x80, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x1A, 0x0C, 0xFE, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0F, 0x00, 0x08,
  0xCC, 0x00, 0x4C, 0x30, 0x02, 0xC0, 0x80, 0x1C, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x30, 0x01, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x81, 0xFE, 0x00, 0x7F, 0x82, 0x1E, 0x1C, 0x07, 0x87, 0x88,
  0xC0, 0x18, 0x30, 0x03, 0x26, 0x00, 0x31, 0x80, 0x06, 0xB0, 0x00, 0x6C,
  0x00, 0x1A, 0x80, 0x00, 0xA0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x80, 0xFF, 0x02, 0x0F, 0x07, 0x88, 0xE0, 0x07, 0x26, 0x00, 0x06,
  0x90, 0x00, 0x1A, 0x80, 0x00, 0x3A, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x80, 0xFF, 0x80, 0x83, 0xE1, 0xE0, 0x86,
  0x00, 0x30, 0x8C, 0x00, 0x18, 0x98, 0x00, 0x0C, 0xB0, 0x00, 0x06, 0xA0,
  0x00, 0x06, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x02, 0xE0, 0x00, 0x06, 0xA0, 0x00, 0x04, 0xF0, 0x00, 0x0C, 0xD8,
  0x00, 0x18, 0xCC, 0x00, 0x30, 0xC7, 0x00, 0xE0, 0xC1, 0xFF, 0x80, 0xC0,
  0x14, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x81, 0x81, 0xE0, 0xF0, 0xC1, 0x80, 0x0C, 0x61,
  0x80, 0x03, 0x31, 0x80, 0x00, 0xD9, 0x80, 0x00, 0x3C, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0x20, 0x00, 0x07, 0x98, 0x00, 0x06, 0xC6,
  0x00, 0x02, 0x61, 0x80, 0x06, 0x30, 0x70, 0x0E, 0x18, 0x0F, 0xFE, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x81, 0xFF, 0x0F, 0x1E, 0x30, 0x04, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x7C, 0x1F, 0x86, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0xCF, 0x00, 0x1C, 0x1F, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x10, 0x1F, 0xE0, 0x06, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x15, 0x00, 0x00, 0xD6,
  0x00, 0x06, 0x4C, 0x00, 0x31, 0x1C, 0x03, 0x84, 0x3F, 0xF8, 0x10, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10,
  0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x05,
  0x00, 0x03, 0x60, 0x00, 0x58, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x62, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x41, 0x00, 0x18, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x03, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01,
  0x00, 0x40, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80,
  0x08, 0x20, 0x02, 0x18, 0x00, 0xC2, 0x00, 0x21, 0x80, 0x04, 0x60, 0x03,
  0x10, 0x00, 0x46, 0x00, 0x13, 0x00, 0x06, 0x40, 0x01, 0x30, 0x00, 0x24,
  0x00, 0x1A, 0x00, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x04, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01,
  0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x66, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC1, 0x80, 0x01,
  0x80, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0x30, 0x08, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01,
  0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7E, 0x00, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x5C, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x1A, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 40, 12, 5, -40 },
  { 16, 10, 14, 18, 4, -40 },
  { 34, 33, 40, 36, 2, -40 },
  { 199, 22, 46, 32, 4, -43 },
  { 326, 38, 42, 44, 3, -41 },
  { 526, 33, 42, 39, 4, -41 },
  { 700, 2, 14, 10, 4, -40 },
  { 704, 10, 49, 14, 2, -40 },
  { 766, 10, 49, 14, 2, -40 },
  { 828, 24, 22, 31, 3, -42 },
  { 894, 26, 26, 32, 3, -33 },
  { 979, 5, 14, 10, 2, -7 },
  { 988, 14, 2, 18, 2, -16 },
  { 992, 3, 3, 12, 5, -3 },
  { 994, 16, 40, 18, 1, -40 },
  { 1074, 25, 42, 32, 3, -41 },
  { 1206, 12, 40, 32, 6, -40 },
  { 1266, 25, 41, 32, 3, -41 },
  { 1395, 25, 42, 32, 3, -41 },
  { 1527, 30, 40, 32, 1, -40 },
  { 1677, 24, 41, 32, 4, -40 },
  { 1800, 25, 42, 32, 4, -41 },
  { 1932, 26, 40, 32, 3, -40 },
  { 2062, 24, 42, 32, 4, -41 },
  { 2188, 25, 42, 32, 3, -41 },
  { 2320, 3, 30, 12, 5, -30 },
  { 2332, 6, 37, 12, 2, -30 },
  { 2360, 26, 25, 32, 3, -33 },
  { 2442, 26, 13, 32, 3, -26 },
  { 2485, 26, 25, 32, 3, -33 },
  { 2567, 19, 41, 23, 2, -41 },
  { 2665, 43, 46, 49, 3, -40 },
  { 2913, 32, 40, 32, 0, -40 },
  { 3073, 25, 40, 34, 6, -40 },
  { 3198, 29, 42, 34, 4, -41 },
  { 3351, 29, 40, 39, 6, -40 },
  { 3496, 21, 40, 31, 6, -40 },
  { 3601, 21, 40, 28, 6, -40 },
  { 3706, 32, 42, 40, 4, -41 },
  { 3874, 28, 40, 40, 6, -40 },
  { 4014, 9, 40, 16, 3, -40 },
  { 4059, 12, 50, 13, -5, -40 },
  { 4134, 25, 40, 31, 6, -40 },
  { 4259, 21, 40, 28, 6, -40 },
  { 4364, 35, 40, 47, 6, -40 },
  { 4539, 27, 40, 39, 6, -40 },
  { 4674, 35, 42, 42, 4, -41 },
  { 4858, 23, 40, 32, 6, -40 },
  { 4973, 35, 51, 42, 4, -41 },
  { 5197, 25, 40, 32, 6, -40 },
  { 5322, 24, 42, 30, 3, -41 },
  { 5448, 28, 40, 28, 0, -40 },
  { 5588, 30, 41, 40, 5, -40 },
  { 5742, 32, 40, 32, 0, -40 },
  { 5902, 45, 40, 49, 2, -40 },
  { 6127, 29, 40, 29, 0, -40 },
  { 6272, 28, 40, 28, 0, -40 },
  { 6412, 28, 40, 32, 2, -40 },
  { 6552, 11, 49, 18, 5, -40 },
  { 6620, 16, 40, 18, 1, -40 },
  { 6700, 12, 49, 18, 1, -40 },
  { 6774, 26, 24, 32, 3, -40 },
  { 6852, 22, 2, 22, 0, 5 },
  { 6858, 10, 9, 14, 2, -43 },
  { 6870, 21, 31, 29, 3, -30 },
  { 6952, 24, 44, 33, 5, -43 },
  { 7084, 22, 31, 26, 3, -30 },
  { 7170, 25, 44, 33, 3, -43 },
  { 7308, 24, 31, 30, 3, -30 },
  { 7401, 18, 43, 15, 1, -43 },
  { 7498, 25, 43, 33, 3, -30 },
  { 7633, 22, 43, 32, 5, -43 },
  { 7752, 3, 40, 12, 4, -40 },
  { 7767, 10, 53, 12, -3, -40 },
  { 7834, 21, 43, 25, 5, -43 },
  { 7947, 2, 43, 12, 5, -43 },
  { 7958, 38, 30, 48, 5, -30 },
  { 8101, 22, 30, 32, 5, -30 },
  { 8184, 26, 31, 32, 3, -30 },
  { 8285, 24, 43, 33, 5, -30 },
  { 8414, 25, 43, 33, 3, -30 },
  { 8549, 15, 30, 21, 5, -30 },
  { 8606, 21, 31, 26, 2, -30 },
  { 8688, 15, 38, 18, 1, -37 },
  { 8760, 22, 31, 32, 5, -30 },
  { 8846, 24, 30, 24, 0, -30 },
  { 8936, 36, 30, 38, 1, -30 },
  { 9071, 24, 30, 27, 1, -30 },
  { 9161, 24, 44, 24, 0, -30 },
  { 9293, 21, 30, 26, 2, -30 },
  { 9372, 16, 49, 19, 1, -40 },
  { 9470, 2, 57, 30, 14, -43 },
  { 9485, 15, 49, 19, 2, -40 },
  { 9577, 26, 5, 32, 3, -22 },
};

const GFXfont NotoSans_Thin56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin56pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_THIN56PT7B_H_
