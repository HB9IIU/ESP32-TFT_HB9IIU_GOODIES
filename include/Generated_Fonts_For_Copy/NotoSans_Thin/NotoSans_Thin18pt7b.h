#ifndef _NOTOSANS_THIN18PT7B_H_
#define _NOTOSANS_THIN18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xDA, 0x08, 0x81, 0x10, 0x22, 0x04, 0x47, 0xFE,
  0x21, 0x04, 0x40, 0x88, 0xFF, 0xC2, 0x20, 0x44, 0x11, 0x02, 0x20, 0x10,
  0x79, 0x4C, 0x89, 0x12, 0x1C, 0x0C, 0x14, 0x24, 0x48, 0x91, 0x3F, 0x84,
  0x00, 0x70, 0x48, 0x88, 0x88, 0x88, 0x90, 0x89, 0x08, 0xAE, 0x8B, 0x17,
  0x51, 0x05, 0x10, 0x91, 0x11, 0x11, 0x11, 0x20, 0xE0, 0x3C, 0x08, 0x41,
  0x04, 0x21, 0x02, 0x20, 0x38, 0x0A, 0x02, 0x21, 0x82, 0x50, 0x2A, 0x02,
  0x40, 0xA7, 0xE2, 0xF8, 0x29, 0x49, 0x24, 0x92, 0x48, 0x91, 0x91, 0x22,
  0x49, 0x24, 0x94, 0xA4, 0x10, 0x10, 0x10, 0xF7, 0x18, 0x18, 0x24, 0x42,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0xF0, 0xF0, 0x80,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x80, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x17,
  0x91, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7C, 0x82, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x7C, 0x82, 0x01, 0x01, 0x02,
  0x02, 0x3C, 0x02, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x01, 0x00, 0xC0, 0x50,
  0x24, 0x09, 0x04, 0x42, 0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01,
  0x00, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0xFE, 0x1F, 0x20, 0x40, 0x40, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x3E, 0xFF, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x3E, 0x41, 0x81, 0x81, 0x42, 0x24, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x7E, 0x7C, 0x82, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x7D, 0x01, 0x01, 0x02, 0x02, 0xFC, 0xC0, 0x40, 0xC0, 0xF0, 0x01, 0x06,
  0x18, 0x60, 0x80, 0x60, 0x1C, 0x02, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0xF8, 0x10, 0x41, 0x04,
  0x21, 0x08, 0x41, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90,
  0x02, 0x87, 0xC6, 0x21, 0x18, 0x84, 0x64, 0x11, 0x90, 0x46, 0x23, 0x18,
  0x73, 0xA0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x04, 0x03, 0x00,
  0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0xFE, 0x20, 0x90, 0x24, 0x06, 0x01,
  0x80, 0x40, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFE, 0x1F, 0xC8, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0x80, 0xFC, 0x41, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x6F, 0xC0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1F,
  0xC4, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0xF4, 0x01, 0x80, 0x30,
  0x05, 0x00, 0x90, 0x11, 0xFC, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0xE9, 0x24, 0x92, 0x49,
  0x2E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x81, 0x82, 0x84,
  0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x30,
  0x07, 0x01, 0xE0, 0x3A, 0x0B, 0x41, 0x68, 0x2C, 0x89, 0x91, 0x31, 0x46,
  0x28, 0xC5, 0x18, 0x42, 0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x23,
  0x11, 0x84, 0xC1, 0x60, 0xB0, 0x38, 0x08, 0x1F, 0x84, 0x09, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0x90, 0x21,
  0xF8, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x1F, 0x84, 0x09, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x00, 0x90, 0x21, 0xE8, 0x02, 0x00, 0x40, 0x06, 0xFC,
  0x82, 0x82, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x82, 0x82, 0x81,
  0x7E, 0x80, 0x80, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x01, 0x01, 0x01,
  0xFE, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x27, 0xE0, 0x80, 0x60, 0x14, 0x09, 0x02,
  0x40, 0x88, 0x42, 0x10, 0x44, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x04, 0x00,
  0x82, 0x06, 0x08, 0x18, 0x30, 0x61, 0x42, 0x45, 0x09, 0x12, 0x24, 0x48,
  0x92, 0x24, 0x28, 0x50, 0xA1, 0x43, 0x06, 0x04, 0x08, 0x10, 0x20, 0x80,
  0xA0, 0x88, 0x44, 0x41, 0x40, 0x40, 0x20, 0x28, 0x12, 0x11, 0x10, 0x48,
  0x28, 0x08, 0x80, 0xA0, 0x50, 0x44, 0x42, 0x20, 0xA0, 0x50, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x0F, 0xF8, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x27, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14, 0x24,
  0x42, 0x42, 0x81, 0x81, 0xFE, 0x89, 0x80, 0x79, 0x08, 0x08, 0x10, 0xEE,
  0x60, 0xC1, 0x86, 0xF4, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0x80, 0x1E, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x7C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x3C, 0x42, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80,
  0x40, 0x3E, 0x1C, 0x82, 0x08, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01,
  0x01, 0x01, 0x7E, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x40, 0x9F, 0xF8, 0x20, 0x12, 0x49, 0x24, 0x92, 0x49,
  0xE0, 0x82, 0x08, 0x20, 0x86, 0x29, 0x28, 0xC2, 0x89, 0x22, 0x8A, 0x10,
  0xFF, 0xFC, 0xF9, 0xE8, 0x61, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x04, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E,
  0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFA, 0x04, 0x08, 0x10,
  0x00, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x01,
  0x01, 0x01, 0x01, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x20, 0x60,
  0x60, 0x41, 0x07, 0xF0, 0x42, 0x2E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x70,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x81, 0x81,
  0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x82, 0x14, 0x61, 0x45,
  0x14, 0x52, 0x49, 0x22, 0x8A, 0x28, 0xC1, 0x04, 0x10, 0x40, 0x81, 0x42,
  0x22, 0x14, 0x18, 0x08, 0x14, 0x24, 0x42, 0xC1, 0x81, 0x81, 0x42, 0x42,
  0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x20, 0xE0, 0xFC, 0x10,
  0x82, 0x10, 0x82, 0x10, 0x83, 0xF0, 0x19, 0x08, 0x42, 0x10, 0x84, 0xE1,
  0x08, 0x42, 0x10, 0x83, 0xFF, 0xFF, 0xE0, 0xC1, 0x08, 0x42, 0x10, 0x84,
  0x39, 0x08, 0x42, 0x10, 0x98, 0xFF,
};

const GFXglyph NotoSans_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 13, 4, 2, -13 },
  { 3, 3, 5, 6, 1, -13 },
  { 5, 11, 13, 12, 0, -13 },
  { 23, 7, 15, 10, 1, -14 },
  { 37, 12, 13, 14, 1, -13 },
  { 57, 11, 13, 13, 1, -13 },
  { 75, 1, 5, 3, 1, -13 },
  { 76, 3, 16, 5, 1, -13 },
  { 82, 3, 16, 5, 1, -13 },
  { 88, 8, 8, 10, 1, -14 },
  { 96, 8, 9, 10, 1, -11 },
  { 105, 1, 4, 3, 1, -2 },
  { 106, 4, 1, 6, 1, -5 },
  { 107, 1, 1, 4, 2, -1 },
  { 108, 6, 13, 6, 0, -13 },
  { 118, 8, 13, 10, 1, -13 },
  { 131, 4, 13, 10, 2, -13 },
  { 138, 8, 13, 10, 1, -13 },
  { 151, 8, 13, 10, 1, -13 },
  { 164, 10, 13, 10, 0, -13 },
  { 181, 8, 13, 10, 1, -13 },
  { 194, 8, 13, 10, 1, -13 },
  { 207, 8, 13, 10, 1, -13 },
  { 220, 8, 13, 10, 1, -13 },
  { 233, 8, 13, 10, 1, -13 },
  { 246, 1, 10, 4, 2, -10 },
  { 248, 1, 12, 4, 1, -10 },
  { 250, 8, 9, 10, 1, -11 },
  { 259, 8, 4, 10, 1, -8 },
  { 263, 8, 9, 10, 1, -11 },
  { 272, 6, 13, 7, 1, -13 },
  { 282, 14, 15, 16, 1, -13 },
  { 309, 10, 13, 10, 0, -13 },
  { 326, 8, 13, 11, 2, -13 },
  { 339, 10, 13, 11, 1, -13 },
  { 356, 9, 13, 12, 2, -13 },
  { 371, 7, 13, 10, 2, -13 },
  { 383, 7, 13, 9, 2, -13 },
  { 395, 11, 13, 13, 1, -13 },
  { 413, 9, 13, 13, 2, -13 },
  { 428, 3, 13, 5, 1, -13 },
  { 433, 4, 16, 4, -2, -13 },
  { 441, 8, 13, 10, 2, -13 },
  { 454, 7, 13, 9, 2, -13 },
  { 466, 11, 13, 15, 2, -13 },
  { 484, 9, 13, 13, 2, -13 },
  { 499, 11, 13, 14, 1, -13 },
  { 517, 7, 13, 10, 2, -13 },
  { 529, 11, 16, 14, 1, -13 },
  { 551, 8, 13, 10, 2, -13 },
  { 564, 8, 13, 10, 1, -13 },
  { 577, 9, 13, 9, 0, -13 },
  { 592, 9, 13, 13, 2, -13 },
  { 607, 10, 13, 10, 0, -13 },
  { 624, 14, 13, 16, 1, -13 },
  { 647, 9, 13, 9, 0, -13 },
  { 662, 9, 13, 9, 0, -13 },
  { 677, 9, 13, 10, 1, -13 },
  { 692, 3, 16, 6, 2, -13 },
  { 698, 6, 13, 6, 0, -13 },
  { 708, 4, 16, 6, 0, -13 },
  { 716, 8, 8, 10, 1, -13 },
  { 724, 7, 1, 7, 0, 1 },
  { 725, 3, 3, 4, 1, -14 },
  { 727, 7, 10, 9, 1, -10 },
  { 736, 7, 14, 11, 2, -14 },
  { 749, 7, 10, 9, 1, -10 },
  { 758, 8, 14, 11, 1, -14 },
  { 772, 8, 10, 10, 1, -10 },
  { 782, 6, 14, 5, 0, -14 },
  { 793, 8, 14, 11, 1, -10 },
  { 807, 7, 14, 10, 2, -14 },
  { 820, 1, 13, 4, 1, -13 },
  { 822, 3, 17, 4, -1, -13 },
  { 829, 6, 14, 8, 2, -14 },
  { 840, 1, 14, 4, 1, -14 },
  { 842, 12, 10, 15, 2, -10 },
  { 857, 7, 10, 10, 2, -10 },
  { 866, 8, 10, 10, 1, -10 },
  { 876, 7, 14, 11, 2, -10 },
  { 889, 8, 14, 11, 1, -10 },
  { 903, 4, 10, 7, 2, -10 },
  { 908, 6, 10, 8, 1, -10 },
  { 916, 5, 12, 6, 0, -12 },
  { 924, 8, 10, 10, 1, -10 },
  { 934, 8, 10, 8, 0, -10 },
  { 944, 12, 9, 12, 0, -9 },
  { 958, 8, 10, 9, 0, -10 },
  { 968, 8, 14, 8, 0, -10 },
  { 982, 6, 10, 8, 1, -10 },
  { 990, 5, 16, 6, 0, -13 },
  { 1000, 1, 19, 10, 4, -14 },
  { 1003, 5, 16, 6, 1, -13 },
  { 1013, 8, 1, 10, 1, -7 },
};

const GFXfont NotoSans_Thin18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin18pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_THIN18PT7B_H_
