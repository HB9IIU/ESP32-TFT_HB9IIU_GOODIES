#ifndef _NOTOSANS_THIN61PT7B_H_
#define _NOTOSANS_THIN61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x00, 0x00, 0x1F, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x68, 0x0D, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x70, 0xC0, 0xF0, 0x60, 0x60, 0x10, 0x60, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0xE0, 0x00, 0x06, 0x3C, 0x00, 0x03,
  0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x30, 0x06, 0x0E,
  0x1F, 0xC3, 0x3E, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0x80, 0x0F, 0x3C, 0x00, 0x00, 0xC0, 0x0E, 0x07, 0x00,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x04, 0x00, 0x04, 0x00, 0x08, 0x06, 0x00, 0x02, 0x00,
  0x04, 0x02, 0x00, 0x01, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x01, 0x01,
  0x00, 0x00, 0x40, 0x01, 0x81, 0x80, 0xE0, 0x30, 0x00, 0xC1, 0x83, 0xFE,
  0x18, 0x00, 0x60, 0xC3, 0x83, 0x8C, 0x00, 0x20, 0xC3, 0x80, 0x62, 0x00,
  0x30, 0x41, 0x80, 0x31, 0x80, 0x18, 0x61, 0x80, 0x0C, 0x60, 0x18, 0x20,
  0xC0, 0x06, 0x38, 0x1C, 0x30, 0x40, 0x03, 0x0F, 0x3C, 0x10, 0x60, 0x00,
  0x81, 0xF8, 0x18, 0x30, 0x00, 0x40, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x04, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x20, 0x00, 0x1C, 0x06, 0x00, 0x30,
  0x00, 0x07, 0x07, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x03,
  0x00, 0x01, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0xC4,
  0x00, 0x01, 0xC0, 0x04, 0x60, 0x00, 0x07, 0x00, 0x63, 0x00, 0x00, 0x1C,
  0x02, 0x18, 0x00, 0x00, 0x70, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x04, 0x00,
  0x00, 0x07, 0x18, 0x30, 0x00, 0x00, 0x1D, 0x81, 0x80, 0x00, 0x00, 0x78,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x01, 0xD8, 0x06, 0x00, 0x00, 0x1C, 0x60, 0x38, 0x00, 0x01, 0x81, 0x80,
  0xE0, 0x00, 0x38, 0x06, 0x01, 0xE0, 0x0F, 0x00, 0x18, 0x03, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x55, 0x55, 0x55, 0x00,
  0xC0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0xF8, 0x04, 0x03, 0xCF, 0x82, 0x0F, 0x80, 0x79, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x08,
  0x00, 0x30, 0x06, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x61,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x0C, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x07, 0xC0, 0x33, 0x01, 0x8C, 0x1C, 0x30, 0xC0, 0xCE, 0x03,
  0x70, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0xF8, 0x01, 0xE0, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0x00, 0x78, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC1,
  0xF0, 0x01, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x30,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x0F, 0x80,
  0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xE0, 0x60, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x03, 0xF0, 0x01, 0x03, 0xFF,
  0xE0, 0x61, 0xE0, 0x0E, 0x0C, 0x70, 0x00, 0x71, 0x98, 0x00, 0x03, 0x36,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x5C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1A, 0x18,
  0x00, 0x03, 0x20, 0xC0, 0x00, 0x62, 0x06, 0x00, 0x1C, 0x20, 0x3E, 0x1F,
  0x02, 0x00, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x10, 0x03, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC2, 0x08, 0x61,
  0x84, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xF0, 0xF8, 0x38, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0x8C, 0x00,
  0x0E, 0x00, 0x20, 0x01, 0x90, 0x00, 0x30, 0x00, 0x40, 0x03, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x06, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x0D, 0x80, 0x0C,
  0x00, 0x02, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x08, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xB0, 0x01, 0x80, 0x00,
  0xA0, 0x03, 0x20, 0x01, 0x80, 0x03, 0x40, 0x04, 0x60, 0x03, 0x00, 0x0C,
  0xC0, 0x18, 0xC0, 0x03, 0x00, 0x31, 0x80, 0x61, 0x80, 0x03, 0x81, 0xC1,
  0xC3, 0x81, 0x00, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x3E, 0x0C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x83, 0xFF, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x80, 0xE3, 0xFF, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC7, 0x60, 0x00,
  0x0C, 0xE3, 0x00, 0x00, 0xDC, 0x30, 0x00, 0x0D, 0x81, 0x80, 0x00, 0xF0,
  0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x01, 0x7B, 0x00, 0x00,
  0x00, 0x06, 0xF2, 0x00, 0x00, 0x00, 0x09, 0xE6, 0x00, 0x00, 0x00, 0x33,
  0xCC, 0x00, 0x00, 0x00, 0x67, 0x8C, 0x00, 0x00, 0x00, 0x8F, 0x18, 0x00,
  0x00, 0x03, 0x1E, 0x10, 0x00, 0x00, 0x04, 0x3C, 0x30, 0x00, 0x00, 0x18,
  0x78, 0x60, 0x00, 0x00, 0x30, 0xF0, 0x60, 0x00, 0x00, 0xC1, 0xE0, 0xC0,
  0x00, 0x01, 0x83, 0xC0, 0x80, 0x00, 0x02, 0x07, 0x81, 0x80, 0x00, 0x0C,
  0x0F, 0x03, 0x00, 0x00, 0x18, 0x1E, 0x03, 0x00, 0x00, 0x60, 0x3C, 0x06,
  0x00, 0x00, 0xC0, 0x78, 0x04, 0x00, 0x01, 0x00, 0xF0, 0x0C, 0x00, 0x06,
  0x01, 0xE0, 0x08, 0x00, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x07, 0x80,
  0x30, 0x00, 0x60, 0x0F, 0x00, 0x20, 0x00, 0x80, 0x1E, 0x00, 0x60, 0x03,
  0x00, 0x3C, 0x00, 0x40, 0x04, 0x00, 0x78, 0x00, 0xC0, 0x18, 0x00, 0xF0,
  0x01, 0x80, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x40, 0x03, 0xC0, 0x03, 0x01,
  0x80, 0x07, 0x80, 0x02, 0x02, 0x00, 0x0F, 0x00, 0x06, 0x0C, 0x00, 0x1E,
  0x00, 0x0C, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x60, 0x00, 0x78, 0x00, 0x18,
  0xC0, 0x00, 0xF0, 0x00, 0x11, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x3C,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xE1, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0xF8,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x1F, 0xE0, 0x1C, 0x00, 0x0F, 0x06, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x01, 0xC3, 0xF0, 0x01,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x38, 0x00, 0x00, 0x26, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x18, 0x80, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x04, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x82, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x20, 0x60,
  0x00, 0x20, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x01, 0x80, 0x04, 0x01,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x80, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x08, 0x00, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00, 0x00, 0x41,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x21, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xC0, 0x7C, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x02, 0x0F, 0x00, 0x04,
  0x70, 0x00, 0x09, 0x80, 0x00, 0x16, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0x2C, 0x00, 0x06, 0x4C, 0x00,
  0x38, 0x8E, 0x01, 0xC1, 0x0F, 0xFF, 0x02, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x3F, 0x80, 0x30, 0x3F, 0xFC,
  0x06, 0x1C, 0x00, 0xE0, 0xC6, 0x00, 0x0E, 0x19, 0x80, 0x00, 0x63, 0x60,
  0x00, 0x0C, 0x68, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x2E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x27, 0x80, 0x00,
  0x0C, 0xF0, 0x00, 0x01, 0x1B, 0x00, 0x00, 0x63, 0x30, 0x00, 0x18, 0x63,
  0x00, 0x0E, 0x0C, 0x38, 0x07, 0x81, 0x83, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x81, 0xE0, 0x07, 0x00, 0xFF, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xE0,
  0x10, 0x1F, 0xFE, 0x04, 0x0E, 0x00, 0xE1, 0x0E, 0x00, 0x0C, 0x47, 0x00,
  0x01, 0x91, 0x80, 0x00, 0x34, 0xC0, 0x00, 0x0D, 0x60, 0x00, 0x01, 0x58,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x05, 0x30, 0x00, 0x03, 0x4C, 0x00, 0x00, 0x91, 0x80, 0x00, 0x64, 0x38,
  0x00, 0x31, 0x07, 0x80, 0x78, 0x40, 0x7F, 0xF8, 0x10, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x04, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0xE0, 0x10, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x0F, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFC, 0x10, 0x78, 0x03, 0x84, 0x38, 0x00, 0x31, 0x18, 0x00,
  0x06, 0xC6, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x14, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x06, 0xC6, 0x00, 0x01, 0xB0, 0xE0,
  0x01, 0xCC, 0x1E, 0x01, 0xE3, 0x01, 0xFF, 0xE0, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x0F,
  0x80, 0x0E, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF4, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0xFC, 0x03, 0x07, 0xFF, 0xC1, 0x87, 0x00, 0x70, 0xC6,
  0x00, 0x0C, 0x66, 0x00, 0x03, 0x36, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x17, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xE0, 0x00,
  0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x83, 0x1F, 0xC0, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x61, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x18,
  0x4C, 0x00, 0x31, 0x98, 0x00, 0x66, 0x18, 0x00, 0xD8, 0x18, 0x01, 0xE0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x30, 0x7F, 0xF0, 0x0F, 0xFF, 0x0C, 0x70, 0x0E, 0x07, 0x00, 0xE3, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0xD8, 0x00, 0x19, 0x80, 0x01, 0xB4, 0x00, 0x06,
  0xC0, 0x00, 0x6F, 0x00, 0x00, 0xA0, 0x00, 0x0B, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0x80, 0x60, 0x7F, 0xF8, 0x30, 0xE0, 0x0E, 0x18, 0xC0,
  0x01, 0x8C, 0xC0, 0x00, 0x66, 0xC0, 0x00, 0x1B, 0x40, 0x00, 0x0D, 0xC0,
  0x00, 0x02, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x7F, 0xF8, 0x08, 0x78,
  0x03, 0x82, 0x38, 0x00, 0x30, 0x98, 0x00, 0x06, 0x24, 0x00, 0x00, 0xCB,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x32, 0xC0, 0x00, 0x0C, 0xB0,
  0x00, 0x06, 0x26, 0x00, 0x03, 0x08, 0xE0, 0x01, 0x82, 0x1E, 0x03, 0xC0,
  0x81, 0xFF, 0xC0, 0x20, 0x07, 0x80, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x04, 0x0F, 0x00, 0x70, 0x83,
  0x80, 0x03, 0x30, 0xC0, 0x00, 0x36, 0x30, 0x00, 0x02, 0xC6, 0x00, 0x00,
  0x79, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xE4, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x98, 0x00, 0x00, 0xF1,
  0x80, 0x00, 0x36, 0x18, 0x00, 0x0C, 0xC1, 0x80, 0x03, 0x18, 0x1C, 0x01,
  0xC3, 0x00, 0xFF, 0xE0, 0x60, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x7C, 0x83, 0xFF, 0x8E, 0x00, 0x98, 0x00,
  0xB0, 0x00, 0xA0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x38, 0x00, 0x70, 0xC0, 0x00, 0x23, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0x7E, 0x00, 0x78, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x02, 0x03,
  0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x60, 0x00,
  0x05, 0x60, 0x00, 0x0D, 0x30, 0x00, 0x19, 0x18, 0x00, 0x71, 0x0E, 0x01,
  0xE1, 0x07, 0xFF, 0x81, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06,
  0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x06, 0x00,
  0x08, 0x01, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x03,
  0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x02, 0x60, 0x00, 0x1C, 0x00, 0x02, 0x60, 0x00, 0x14, 0x00, 0x06, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x20, 0x00, 0x26, 0x00, 0x04, 0x30, 0x00, 0x22,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x0C,
  0x10, 0x00, 0x41, 0x00, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x00,
  0x81, 0x80, 0x18, 0x08, 0x00, 0x80, 0x80, 0x10, 0x0C, 0x01, 0x80, 0x80,
  0x10, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x04,
  0x03, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x02, 0x06, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x30, 0x40,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x0C,
  0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x09,
  0x80, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xD0, 0x00, 0x0D, 0x00, 0x00,
  0xF0, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x08, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x10,
  0x00, 0x30, 0x06, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04,
  0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xC0,
  0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xC3, 0xC0, 0x01, 0x60, 0x07,
  0x80, 0x3C, 0x00, 0x1E, 0x1E, 0x80, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 44, 14, 5, -44 },
  { 18, 11, 16, 20, 4, -44 },
  { 40, 36, 44, 39, 2, -44 },
  { 238, 25, 50, 35, 4, -46 },
  { 395, 41, 45, 48, 4, -44 },
  { 626, 37, 45, 43, 4, -44 },
  { 835, 2, 16, 10, 4, -44 },
  { 839, 10, 54, 16, 3, -44 },
  { 907, 11, 54, 16, 2, -44 },
  { 982, 25, 24, 34, 4, -46 },
  { 1057, 28, 29, 35, 3, -36 },
  { 1159, 6, 15, 11, 2, -7 },
  { 1171, 15, 1, 20, 2, -17 },
  { 1173, 3, 3, 13, 5, -3 },
  { 1175, 18, 44, 20, 1, -44 },
  { 1274, 27, 45, 35, 4, -44 },
  { 1426, 14, 44, 35, 6, -44 },
  { 1503, 26, 44, 35, 4, -44 },
  { 1646, 27, 45, 35, 3, -44 },
  { 1798, 32, 44, 35, 2, -44 },
  { 1974, 26, 45, 35, 5, -44 },
  { 2121, 27, 45, 35, 4, -44 },
  { 2273, 27, 44, 35, 4, -44 },
  { 2422, 27, 45, 35, 4, -44 },
  { 2574, 28, 45, 35, 3, -44 },
  { 2732, 3, 32, 13, 5, -32 },
  { 2744, 6, 40, 13, 2, -32 },
  { 2774, 28, 28, 35, 3, -36 },
  { 2872, 28, 13, 35, 3, -28 },
  { 2918, 28, 28, 35, 3, -36 },
  { 3016, 21, 44, 25, 2, -44 },
  { 3132, 47, 49, 54, 3, -43 },
  { 3420, 35, 44, 35, 0, -44 },
  { 3613, 28, 44, 37, 6, -44 },
  { 3767, 32, 45, 37, 4, -44 },
  { 3947, 32, 44, 42, 6, -44 },
  { 4123, 24, 44, 34, 6, -44 },
  { 4255, 24, 44, 30, 6, -44 },
  { 4387, 35, 45, 44, 4, -44 },
  { 4584, 31, 44, 43, 6, -44 },
  { 4755, 10, 44, 17, 4, -44 },
  { 4810, 14, 55, 14, -6, -44 },
  { 4907, 28, 44, 34, 6, -44 },
  { 5061, 24, 44, 31, 6, -44 },
  { 5193, 39, 44, 51, 6, -44 },
  { 5408, 30, 44, 43, 6, -44 },
  { 5573, 38, 45, 46, 4, -44 },
  { 5787, 25, 44, 35, 6, -44 },
  { 5925, 38, 54, 46, 4, -44 },
  { 6182, 28, 44, 35, 6, -44 },
  { 6336, 27, 45, 33, 3, -44 },
  { 6488, 31, 44, 31, 0, -44 },
  { 6659, 32, 45, 43, 6, -44 },
  { 6839, 34, 44, 34, 0, -44 },
  { 7026, 49, 44, 53, 2, -44 },
  { 7296, 31, 44, 31, 0, -44 },
  { 7467, 31, 44, 31, 0, -44 },
  { 7638, 31, 44, 35, 2, -44 },
  { 7809, 13, 54, 19, 5, -44 },
  { 7897, 18, 44, 20, 1, -44 },
  { 7996, 12, 54, 19, 2, -44 },
  { 8077, 29, 27, 35, 3, -44 },
  { 8175, 24, 1, 24, 0, 6 },
  { 8178, 11, 10, 15, 2, -47 },
  { 8192, 23, 34, 31, 3, -33 },
  { 8290, 27, 47, 36, 5, -46 },
  { 8449, 23, 34, 29, 4, -33 },
  { 8547, 26, 47, 36, 4, -46 },
  { 8700, 25, 34, 33, 4, -33 },
  { 8807, 20, 47, 17, 1, -47 },
  { 8925, 26, 48, 36, 4, -33 },
  { 9081, 25, 46, 35, 5, -46 },
  { 9225, 3, 44, 13, 5, -44 },
  { 9242, 11, 59, 13, -3, -44 },
  { 9324, 23, 46, 28, 5, -46 },
  { 9457, 1, 46, 13, 6, -46 },
  { 9463, 42, 33, 52, 5, -33 },
  { 9637, 25, 33, 35, 5, -33 },
  { 9741, 27, 34, 35, 4, -33 },
  { 9856, 26, 47, 36, 6, -33 },
  { 10009, 27, 47, 36, 3, -33 },
  { 10168, 16, 33, 23, 6, -33 },
  { 10234, 23, 34, 28, 2, -33 },
  { 10332, 17, 41, 19, 1, -40 },
  { 10420, 24, 33, 35, 5, -32 },
  { 10519, 26, 32, 26, 0, -32 },
  { 10623, 40, 32, 42, 1, -32 },
  { 10783, 25, 32, 29, 2, -32 },
  { 10883, 26, 47, 26, 0, -32 },
  { 11036, 23, 32, 28, 2, -32 },
  { 11128, 16, 54, 21, 2, -44 },
  { 11236, 2, 62, 33, 15, -47 },
  { 11252, 17, 54, 21, 2, -44 },
  { 11367, 28, 5, 35, 3, -24 },
};

const GFXfont NotoSans_Thin61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin61pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_THIN61PT7B_H_
