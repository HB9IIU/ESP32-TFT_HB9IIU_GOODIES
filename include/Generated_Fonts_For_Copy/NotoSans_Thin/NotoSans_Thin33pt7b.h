#ifndef _NOTOSANS_THIN33PT7B_H_
#define _NOTOSANS_THIN33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x0B, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x00, 0x81, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x7F, 0xFF, 0xE0,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01,
  0x02, 0x00, 0x20, 0x40, 0xFF, 0xFF, 0xC1, 0x01, 0x00, 0x20, 0x20, 0x04,
  0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x02,
  0x00, 0x10, 0x07, 0xF8, 0x44, 0x24, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x02, 0x10, 0x10, 0x80, 0x64, 0x00, 0xE0, 0x01, 0xC0, 0x09, 0x80,
  0x42, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x5C, 0x4C, 0x1F, 0x80, 0x10, 0x00, 0x80, 0x1C, 0x00, 0x41, 0x8C, 0x01,
  0x04, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x08, 0x08,
  0x08, 0x20, 0x20, 0x21, 0x00, 0x80, 0x84, 0x02, 0x02, 0x21, 0x08, 0x08,
  0x9B, 0x20, 0x24, 0x82, 0x41, 0x22, 0x05, 0x88, 0x90, 0x11, 0xC4, 0x40,
  0x40, 0x11, 0x01, 0x00, 0x84, 0x04, 0x02, 0x10, 0x10, 0x10, 0x40, 0x40,
  0x41, 0x01, 0x02, 0x02, 0x04, 0x10, 0x08, 0x10, 0x40, 0x20, 0x82, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xC3, 0x00, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x01, 0x00, 0x08, 0x30, 0x00,
  0x44, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x18, 0x80, 0x02, 0x04, 0x02,
  0x40, 0x20, 0x24, 0x01, 0x02, 0x80, 0x08, 0x48, 0x00, 0x44, 0x80, 0x02,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x84, 0x00, 0x64, 0x20, 0x08, 0x61, 0xFF,
  0x03, 0xFF, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x04, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x81, 0x07, 0x84, 0x71, 0xDE, 0x00,
  0xC0, 0x02, 0x80, 0x12, 0x00, 0x84, 0x04, 0x08, 0x30, 0x30, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F,
  0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x24, 0xA4, 0x94, 0xFF, 0xB0, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x03, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x44, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x09,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x01, 0x04, 0x04, 0x07, 0xF0, 0x01,
  0x07, 0x09, 0x11, 0x61, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F,
  0x80, 0xC1, 0x84, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFF, 0x0F, 0xC1, 0xC0, 0xC8, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x07, 0xF0, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x28, 0x01, 0x1F, 0xF8, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x02, 0x10, 0x02, 0x08, 0x02, 0x04, 0x01, 0x02, 0x01, 0x01,
  0x01, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x7F,
  0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0x82, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x30, 0x04, 0x1F, 0xF0, 0x01,
  0xF8, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x03, 0x02, 0x39, 0xC4, 0x80, 0x4A, 0x00, 0x58,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x12, 0x00, 0x44, 0x00, 0x84, 0x06, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x20, 0x08, 0x20, 0x60,
  0x31, 0x00, 0x1C, 0x00, 0xC6, 0x06, 0x02, 0x10, 0x02, 0x20, 0x02, 0x80,
  0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x48, 0x00, 0x88, 0x06,
  0x0F, 0xF0, 0x0F, 0xC0, 0x60, 0x41, 0x80, 0x42, 0x00, 0x48, 0x00, 0x90,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x1A, 0x00,
  0x54, 0x01, 0xA6, 0x04, 0x83, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xC0, 0xB0,
  0x00, 0x00, 0x00, 0xB0, 0x23, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22,
  0x24, 0x44, 0x48, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0x18, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x03, 0x03, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x09, 0x00, 0x3C, 0x04, 0x80, 0xE1, 0x81, 0x80, 0x80, 0x40,
  0xC0, 0x40, 0x20, 0x60, 0x40, 0x10, 0x30, 0x20, 0x08, 0x18, 0x10, 0x04,
  0x0C, 0x10, 0x04, 0x06, 0x08, 0x02, 0x03, 0x02, 0x01, 0x01, 0x81, 0x00,
  0xC1, 0x40, 0xC0, 0xA0, 0xA0, 0x3B, 0x89, 0x88, 0x02, 0x03, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10,
  0x40, 0x02, 0x08, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x03, 0xFF, 0x80, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x0C, 0x00, 0x01, 0xFE, 0x81, 0x00, 0xE2, 0x00, 0x34, 0x00, 0x28, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x67,
  0xFF, 0x08, 0x01, 0x90, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x06, 0x7F, 0xF0,
  0x00, 0xFE, 0x01, 0x80, 0xC3, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x20, 0x3C, 0x08, 0x00, 0xC2, 0x00, 0x08,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x02, 0x20, 0x01, 0x08, 0x03, 0x83, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x1C, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00,
  0x90, 0x00, 0x13, 0x00, 0x02, 0x30, 0x00, 0x41, 0x00, 0x08, 0x1F, 0xFE,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x9F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0xDE, 0x00, 0x80, 0x03, 0x00,
  0x0A, 0x00, 0x24, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80,
  0x82, 0x01, 0x08, 0x02, 0x30, 0x04, 0xA0, 0x0A, 0x20, 0x18, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00, 0x88, 0x00,
  0x90, 0x01, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE8, 0x00, 0x07, 0x40, 0x00, 0x3A, 0x00, 0x02, 0xC8, 0x00,
  0x16, 0x40, 0x01, 0x31, 0x00, 0x09, 0x88, 0x00, 0x4C, 0x20, 0x04, 0x61,
  0x00, 0x23, 0x08, 0x02, 0x18, 0x20, 0x10, 0xC1, 0x01, 0x06, 0x04, 0x08,
  0x30, 0x20, 0x41, 0x81, 0x04, 0x0C, 0x04, 0x20, 0x60, 0x22, 0x03, 0x00,
  0x90, 0x18, 0x04, 0x80, 0xC0, 0x28, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C, 0xC0,
  0x06, 0x20, 0x03, 0x08, 0x01, 0x86, 0x00, 0xC1, 0x00, 0x60, 0x40, 0x30,
  0x30, 0x18, 0x08, 0x0C, 0x02, 0x06, 0x00, 0x83, 0x00, 0x41, 0x80, 0x10,
  0xC0, 0x04, 0x60, 0x02, 0x30, 0x00, 0x98, 0x00, 0x2C, 0x00, 0x16, 0x00,
  0x07, 0x00, 0x01, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x20, 0x20,
  0x00, 0x82, 0x00, 0x02, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x04, 0x08, 0x00,
  0x60, 0x30, 0x06, 0x00, 0x7F, 0xC0, 0xFD, 0x02, 0x03, 0x88, 0x01, 0xA0,
  0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xA0, 0x06, 0x80, 0x63, 0xFE, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x20, 0x20, 0x00, 0x82, 0x00,
  0x02, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x04, 0x08, 0x00, 0x60, 0x30, 0x06,
  0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0xFF, 0x01, 0x01, 0xC2, 0x00,
  0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x1E, 0x1F, 0xD0, 0x20, 0x30, 0x40,
  0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x00,
  0xA0, 0x01, 0x40, 0x01, 0x0F, 0xE0, 0xC0, 0x74, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x28, 0x01, 0x3F, 0xF8, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x14, 0x00, 0x11, 0x00, 0x08,
  0x40, 0x18, 0x1F, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x44, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x08, 0x01, 0x02, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x09, 0x00, 0x30, 0x01, 0x20,
  0x05, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x24, 0x01, 0x08, 0x04, 0x80,
  0x21, 0x00, 0x88, 0x04, 0x20, 0x11, 0x01, 0x02, 0x04, 0x20, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x10, 0x81, 0x04,
  0x02, 0x10, 0x10, 0x80, 0x42, 0x02, 0x10, 0x08, 0x80, 0x44, 0x00, 0x90,
  0x04, 0x80, 0x12, 0x00, 0x90, 0x02, 0x40, 0x14, 0x00, 0x30, 0x02, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x40, 0x01,
  0x20, 0x00, 0x88, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x40, 0x40, 0x10,
  0x40, 0x08, 0x20, 0x02, 0x20, 0x01, 0x30, 0x00, 0x50, 0x00, 0x10, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x04,
  0x06, 0x02, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00, 0x05, 0x00,
  0x01, 0x80, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x40,
  0x80, 0x20, 0x40, 0x20, 0x10, 0x10, 0x08, 0x10, 0x02, 0x08, 0x01, 0x08,
  0x00, 0x44, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xFC, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x44, 0x01, 0x04,
  0x02, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x24,
  0x00, 0x50, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0xC0, 0x81, 0x02, 0x04,
  0x0F, 0x07, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x07, 0xF3, 0x81, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0xC0, 0x57, 0xF9, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x21, 0xF0, 0x98, 0x32, 0x80, 0x6C, 0x00, 0xB0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x2C, 0x00, 0xA8, 0x0C, 0x9F, 0xC0, 0x03,
  0xE0, 0x60, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x41, 0xF1, 0x18, 0x34, 0x80, 0x54, 0x00,
  0xD0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x34, 0x00, 0xCC, 0x05, 0x1F,
  0xE4, 0x07, 0xC0, 0x60, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x08, 0x3F, 0xE0, 0x03, 0xE0, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7C, 0xF8, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x07, 0xC0, 0x60, 0xD2,
  0x00, 0xD0, 0x03, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0xD0, 0x03,
  0x30, 0x14, 0x3F, 0x90, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x60, 0x30, 0x7F, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0xF0, 0x98, 0x65, 0x00, 0xB0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0xC1,
  0xFF, 0xFF, 0x04, 0x10, 0x00, 0x00, 0x00, 0x01, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0xBC, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x28, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x88,
  0x09, 0x80, 0xA4, 0x0C, 0x60, 0xC2, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80,
  0x48, 0x02, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x01, 0xE2, 0x43,
  0x18, 0x6A, 0x02, 0x80, 0xF0, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40,
  0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18,
  0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x10, 0x07, 0x84,
  0xC3, 0x28, 0x05, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x24,
  0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x90, 0x01, 0x10, 0x04, 0x30, 0x10,
  0x1F, 0xC0, 0x07, 0xC2, 0x60, 0xCA, 0x01, 0xB0, 0x02, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0xB8, 0x02, 0xB0, 0x12, 0x7F, 0x88, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x07, 0xC0, 0x60, 0x92, 0x01, 0x50, 0x03, 0x40, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x14, 0x00, 0xD0, 0x03, 0x20, 0x14, 0x7F, 0x90, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0x48,
  0x68, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x0F, 0x81, 0x81, 0x90, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x02, 0x80, 0x33, 0xFE,
  0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFC, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x03, 0xF0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0xA8, 0x0D, 0x3F, 0x88, 0x80, 0x05, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x41, 0x01, 0x04, 0x08, 0x10,
  0x20, 0x21, 0x00, 0x84, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x80, 0x60, 0x14, 0x04, 0x80,
  0xA0, 0x24, 0x04, 0x81, 0x20, 0x44, 0x09, 0x02, 0x20, 0x84, 0x10, 0x84,
  0x21, 0x04, 0x21, 0x08, 0x21, 0x04, 0x40, 0x90, 0x24, 0x04, 0x81, 0x20,
  0x24, 0x09, 0x01, 0x40, 0x30, 0x06, 0x01, 0x80, 0x30, 0x08, 0x00, 0x80,
  0xC0, 0x08, 0x80, 0x42, 0x02, 0x04, 0x08, 0x08, 0x40, 0x22, 0x00, 0x50,
  0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0x88, 0x02, 0x10, 0x10, 0x20, 0x80,
  0x82, 0x01, 0x10, 0x02, 0x80, 0x0C, 0x80, 0x05, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x20, 0x10, 0x80, 0x41, 0x01, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00,
  0x84, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8, 0x01, 0x83, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x83, 0x80, 0xC0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x06, 0x06, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x0F, 0x00, 0x7E, 0x03, 0x03, 0x0E, 0x01, 0xE0,
};

const GFXglyph NotoSans_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 24, 7, 3, -24 },
  { 7, 6, 9, 11, 2, -24 },
  { 14, 19, 24, 21, 1, -24 },
  { 71, 13, 27, 19, 2, -25 },
  { 115, 22, 24, 26, 2, -24 },
  { 181, 20, 24, 23, 2, -24 },
  { 241, 1, 9, 6, 2, -24 },
  { 243, 6, 29, 8, 1, -24 },
  { 265, 6, 29, 8, 1, -24 },
  { 287, 14, 13, 18, 2, -25 },
  { 310, 15, 15, 19, 2, -19 },
  { 339, 3, 8, 6, 1, -4 },
  { 342, 8, 1, 11, 1, -9 },
  { 343, 2, 2, 7, 3, -2 },
  { 344, 10, 24, 11, 0, -24 },
  { 374, 15, 24, 19, 2, -24 },
  { 419, 8, 24, 19, 3, -24 },
  { 443, 14, 24, 19, 2, -24 },
  { 485, 14, 24, 19, 2, -24 },
  { 527, 17, 24, 19, 1, -24 },
  { 578, 15, 24, 19, 2, -24 },
  { 623, 15, 24, 19, 2, -24 },
  { 668, 15, 24, 19, 2, -24 },
  { 713, 15, 24, 19, 2, -24 },
  { 758, 15, 24, 19, 2, -24 },
  { 803, 2, 18, 7, 3, -18 },
  { 808, 4, 22, 7, 1, -18 },
  { 819, 15, 14, 19, 2, -19 },
  { 846, 15, 7, 19, 2, -15 },
  { 860, 15, 14, 19, 2, -19 },
  { 887, 11, 24, 14, 1, -24 },
  { 920, 25, 26, 29, 2, -23 },
  { 1002, 19, 24, 19, 0, -24 },
  { 1059, 15, 24, 20, 3, -24 },
  { 1104, 17, 24, 20, 2, -24 },
  { 1155, 18, 24, 23, 3, -24 },
  { 1209, 13, 24, 18, 3, -24 },
  { 1248, 13, 24, 16, 3, -24 },
  { 1287, 19, 24, 24, 2, -24 },
  { 1344, 17, 24, 23, 3, -24 },
  { 1395, 5, 24, 9, 2, -24 },
  { 1410, 7, 30, 8, -3, -24 },
  { 1437, 15, 24, 18, 3, -24 },
  { 1482, 13, 24, 17, 3, -24 },
  { 1521, 21, 24, 28, 3, -24 },
  { 1584, 17, 24, 23, 3, -24 },
  { 1635, 21, 24, 25, 2, -24 },
  { 1698, 14, 24, 19, 3, -24 },
  { 1740, 21, 30, 25, 2, -24 },
  { 1819, 15, 24, 19, 3, -24 },
  { 1864, 14, 24, 18, 2, -24 },
  { 1906, 17, 24, 17, 0, -24 },
  { 1957, 17, 24, 24, 3, -24 },
  { 2008, 19, 24, 19, 0, -24 },
  { 2065, 27, 24, 29, 1, -24 },
  { 2146, 17, 24, 17, 0, -24 },
  { 2197, 17, 24, 17, 0, -24 },
  { 2248, 17, 24, 19, 1, -24 },
  { 2299, 7, 29, 10, 3, -24 },
  { 2325, 10, 24, 11, 0, -24 },
  { 2355, 6, 29, 10, 1, -24 },
  { 2377, 15, 15, 19, 2, -24 },
  { 2406, 13, 1, 13, 0, 3 },
  { 2408, 6, 5, 8, 1, -25 },
  { 2412, 12, 18, 17, 2, -18 },
  { 2439, 14, 25, 19, 3, -25 },
  { 2483, 13, 18, 16, 2, -18 },
  { 2513, 14, 25, 19, 2, -25 },
  { 2557, 14, 18, 18, 2, -18 },
  { 2589, 11, 25, 9, 0, -25 },
  { 2624, 14, 26, 19, 2, -18 },
  { 2670, 13, 25, 19, 3, -25 },
  { 2711, 1, 24, 7, 3, -24 },
  { 2714, 6, 32, 7, -2, -24 },
  { 2738, 12, 25, 15, 3, -25 },
  { 2776, 1, 25, 7, 3, -25 },
  { 2780, 22, 18, 28, 3, -18 },
  { 2830, 13, 18, 19, 3, -18 },
  { 2860, 15, 18, 19, 2, -18 },
  { 2894, 14, 26, 19, 3, -18 },
  { 2940, 14, 26, 19, 2, -18 },
  { 2986, 9, 18, 12, 3, -18 },
  { 3007, 13, 18, 15, 1, -18 },
  { 3037, 10, 22, 11, 0, -22 },
  { 3065, 13, 17, 19, 3, -17 },
  { 3093, 14, 17, 14, 0, -17 },
  { 3123, 21, 17, 23, 1, -17 },
  { 3168, 14, 17, 16, 1, -17 },
  { 3198, 14, 25, 14, 0, -17 },
  { 3242, 13, 17, 15, 1, -17 },
  { 3270, 9, 29, 11, 1, -24 },
  { 3303, 1, 33, 18, 8, -25 },
  { 3308, 9, 29, 11, 1, -24 },
  { 3341, 15, 3, 19, 2, -13 },
};

const GFXfont NotoSans_Thin33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin33pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_THIN33PT7B_H_
