#ifndef _NOTOSANS_THIN32PT7B_H_
#define _NOTOSANS_THIN32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x86, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x01, 0x01,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x04,
  0x00, 0x81, 0x03, 0xFF, 0xFF, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10,
  0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x07, 0xFF, 0xFE,
  0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x01, 0x00,
  0x20, 0x40, 0x04, 0x08, 0x00, 0x02, 0x00, 0x38, 0x0E, 0xBC, 0x84, 0x04,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10, 0x08, 0x80, 0x34,
  0x00, 0x70, 0x01, 0x60, 0x08, 0x80, 0x42, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x81, 0x0B, 0x89, 0x81, 0xF0, 0x02, 0x00, 0x10, 0x00,
  0x3E, 0x00, 0x82, 0x10, 0x04, 0x10, 0x40, 0x41, 0x02, 0x02, 0x08, 0x08,
  0x20, 0x40, 0x41, 0x02, 0x02, 0x10, 0x10, 0x11, 0x00, 0x80, 0x88, 0x04,
  0x04, 0x8F, 0x20, 0x44, 0x84, 0x82, 0x48, 0x14, 0x22, 0x40, 0x9E, 0x22,
  0x04, 0x01, 0x10, 0x20, 0x10, 0x81, 0x01, 0x04, 0x08, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x40, 0x82, 0x01, 0x08, 0x20, 0x07,
  0x80, 0x07, 0xE0, 0x01, 0x02, 0x00, 0x40, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x04, 0x00, 0x80, 0x80, 0x08, 0x60, 0x00, 0x90,
  0x00, 0x1C, 0x00, 0x04, 0x80, 0x03, 0x08, 0x02, 0x80, 0x80, 0x50, 0x08,
  0x14, 0x00, 0x82, 0x80, 0x08, 0x90, 0x00, 0x92, 0x00, 0x0C, 0x40, 0x01,
  0x84, 0x00, 0x48, 0x40, 0x30, 0x87, 0xF8, 0x08, 0xFF, 0x04, 0x21, 0x04,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x84, 0x30, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0C, 0x20, 0x9D,
  0x38, 0x1E, 0x00, 0x60, 0x04, 0x80, 0x44, 0x04, 0x10, 0x60, 0x41, 0x02,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x24, 0xA4, 0x94, 0xFF, 0xC0, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x0C, 0x00, 0x0F, 0xC0, 0x40, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x20, 0x10, 0x40, 0xC0, 0xFC, 0x00, 0x02, 0x0C, 0x69, 0x1C, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x1F, 0xC1, 0x80, 0x84, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x60,
  0x31, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x58, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00,
  0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x04, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x3E, 0x07,
  0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0A, 0x00, 0xC7, 0xFC, 0x00, 0x03,
  0xF8, 0x30, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x3F, 0x89, 0x01, 0x28, 0x02, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x20, 0x08,
  0x40, 0x40, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0xC0,
  0x44, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x20,
  0x10, 0x61, 0x80, 0x78, 0x03, 0x30, 0x10, 0x31, 0x80, 0x24, 0x00, 0xA0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x08, 0x80, 0x41,
  0xFE, 0x00, 0x1F, 0xC0, 0x80, 0x84, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xD0, 0x05, 0x20,
  0x24, 0x7F, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x07, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x24, 0x00,
  0x00, 0x00, 0x00, 0x49, 0x49, 0x28, 0x00, 0x04, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0x10, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x2C, 0x00,
  0x01, 0xC1, 0xE0, 0x06, 0x00, 0x10, 0x08, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x3F, 0x81, 0x80, 0xC0, 0x81,
  0x80, 0x80, 0x81, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x82, 0x00, 0x81,
  0x82, 0x00, 0x81, 0x82, 0x00, 0x81, 0x82, 0x00, 0x81, 0x81, 0x01, 0x81,
  0x81, 0x02, 0x82, 0x80, 0xC4, 0x44, 0x40, 0x18, 0x38, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x20, 0x02, 0x08, 0x01,
  0x02, 0x00, 0x40, 0x40, 0x20, 0x10, 0x08, 0x02, 0x03, 0xFF, 0x81, 0x00,
  0x20, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x50, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xC1, 0x00, 0x62, 0x00,
  0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x33, 0xFF, 0x84, 0x07, 0x88, 0x00, 0x90, 0x00, 0xA0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x03,
  0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0x00, 0xC2, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x40, 0x18, 0x20, 0x03, 0x10, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00,
  0xC4, 0x01, 0x83, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xFF, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x81,
  0x80, 0x10, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x43, 0x00, 0x10, 0x3F,
  0xF8, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x13, 0xE0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x14, 0x63, 0x00, 0x80, 0x07, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08,
  0x04, 0x10, 0x10, 0x20, 0x40, 0x41, 0x00, 0x84, 0x01, 0x10, 0x02, 0x50,
  0x05, 0x20, 0x0C, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x41,
  0x00, 0x42, 0x00, 0xC4, 0x00, 0x88, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0xFF, 0xE0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x3A, 0x00, 0x03,
  0xA0, 0x00, 0x59, 0x00, 0x05, 0x90, 0x00, 0x58, 0x80, 0x09, 0x88, 0x00,
  0x98, 0x80, 0x11, 0x84, 0x01, 0x18, 0x40, 0x21, 0x82, 0x02, 0x18, 0x20,
  0x21, 0x81, 0x04, 0x18, 0x10, 0x41, 0x81, 0x08, 0x18, 0x08, 0x81, 0x80,
  0x88, 0x18, 0x05, 0x01, 0x80, 0x50, 0x18, 0x06, 0x01, 0x80, 0x20, 0x10,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x98, 0x01,
  0x88, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11, 0x80, 0x09,
  0x80, 0x09, 0x80, 0x05, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x03, 0xFC,
  0x00, 0xC0, 0x30, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04,
  0x10, 0x00, 0x80, 0xC0, 0x10, 0x03, 0xFE, 0x00, 0xFF, 0x82, 0x01, 0x88,
  0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x08, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xC0, 0x30, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x04, 0x10, 0x00, 0x80, 0xC0, 0x10, 0x03, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0xFF,
  0x81, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00, 0x90, 0x00, 0xA0, 0x01,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x03, 0x0F, 0xF8, 0x10,
  0x10, 0x20, 0x30, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00,
  0xC8, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80, 0x1F, 0xF0, 0x80, 0x24, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0A, 0x00, 0xCF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x50, 0x00, 0x48, 0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x3F, 0xE0, 0x80,
  0x00, 0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x08, 0x40, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x14, 0x00, 0xC0,
  0x09, 0x00, 0x50, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x42, 0x01,
  0x20, 0x10, 0x80, 0x88, 0x04, 0x20, 0x21, 0x01, 0x04, 0x08, 0x40, 0x81,
  0x02, 0x10, 0x20, 0x41, 0x04, 0x08, 0x10, 0x40, 0x84, 0x02, 0x10, 0x21,
  0x00, 0x88, 0x08, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x01, 0x20,
  0x12, 0x00, 0x50, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x30, 0x00,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x40, 0x01, 0x20, 0x02, 0x20, 0x04,
  0x10, 0x04, 0x10, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20, 0x02, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x04, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20,
  0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x04, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x00,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x10, 0x08,
  0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40,
  0x02, 0xC0, 0x03, 0xFF, 0xF8, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x84,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x1F, 0x1E, 0x16,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x58, 0x0D, 0x7F, 0x10,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x23, 0xF0, 0xB0, 0x33, 0x00, 0x4C, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80,
  0x0B, 0x00, 0x4A, 0x02, 0x27, 0xF0, 0x07, 0xF1, 0x80, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x43, 0xF1, 0x30, 0x34,
  0x80, 0x54, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x0D, 0x00, 0x52, 0x01,
  0x47, 0xF9, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x80, 0x14, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xFF, 0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x01, 0x0F, 0xF0, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x07, 0xF8, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x0F, 0xE4, 0xC0, 0x52, 0x00, 0xD0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0D, 0x00, 0x34, 0x01, 0x48, 0x0D, 0x1F, 0xC4, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x1C, 0x18, 0x07, 0x80, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0xF8,
  0xA0, 0x26, 0x00, 0xB0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x54, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x0E, 0x26, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02, 0x80, 0x48, 0x08, 0x81,
  0x08, 0x20, 0x84, 0x08, 0x80, 0x98, 0x0A, 0x80, 0xA4, 0x0C, 0x20, 0x81,
  0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x28, 0x03, 0xFF, 0xFF, 0xFF, 0x9F,
  0x87, 0xE2, 0x81, 0x20, 0x6C, 0x03, 0x00, 0xA0, 0x0C, 0x02, 0x80, 0x20,
  0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06,
  0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x04, 0x9F, 0xC5,
  0x01, 0x30, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x0F, 0xE0, 0xC0, 0x42, 0x00, 0x90, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x8C, 0x04, 0x0F, 0xE0, 0x8F, 0xC2, 0xC0, 0xCA,
  0x01, 0x30, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0B, 0x00, 0x2C, 0x01, 0x28, 0x0C,
  0x9F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x0F, 0xC4, 0xC0, 0xD4, 0x01, 0x50, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0D, 0x00, 0x34, 0x01, 0x48, 0x0D, 0x1F, 0xC4, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x9F, 0xA0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1F, 0xE2, 0x01, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0xC0, 0x03, 0x80, 0x04, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x02, 0x7F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0xF8, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x34, 0x05, 0x3F, 0x90, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0x84,
  0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x90, 0x24,
  0x09, 0x02, 0x40, 0x88, 0x22, 0x10, 0x82, 0x21, 0x08, 0x42, 0x10, 0x44,
  0x22, 0x04, 0x41, 0x20, 0x48, 0x12, 0x02, 0x81, 0x40, 0x28, 0x0C, 0x02,
  0x80, 0xC0, 0x10, 0x08, 0x01, 0x00, 0x80, 0x0A, 0x00, 0x88, 0x08, 0x20,
  0x41, 0x04, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x02, 0x00, 0x28, 0x02, 0x20,
  0x11, 0x01, 0x04, 0x10, 0x10, 0x80, 0x48, 0x02, 0x80, 0x08, 0x80, 0x06,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x21, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x03, 0x86, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x03, 0x03,
  0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x18,
  0x0E, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x1C, 0x00, 0x1C, 0x03, 0x0C, 0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 23, 7, 3, -23 },
  { 4, 6, 8, 10, 2, -23 },
  { 10, 19, 23, 21, 1, -23 },
  { 65, 13, 26, 18, 2, -24 },
  { 108, 21, 23, 25, 2, -23 },
  { 169, 19, 23, 22, 2, -23 },
  { 224, 1, 8, 6, 2, -23 },
  { 225, 6, 28, 8, 1, -23 },
  { 246, 6, 28, 8, 1, -23 },
  { 267, 13, 13, 18, 2, -24 },
  { 289, 14, 15, 18, 2, -19 },
  { 316, 3, 8, 6, 1, -4 },
  { 319, 8, 1, 10, 1, -9 },
  { 320, 1, 2, 7, 3, -2 },
  { 321, 10, 23, 10, 0, -23 },
  { 350, 14, 23, 18, 2, -23 },
  { 391, 7, 23, 18, 3, -23 },
  { 412, 14, 23, 18, 2, -23 },
  { 453, 15, 23, 18, 1, -23 },
  { 497, 17, 23, 18, 1, -23 },
  { 546, 14, 23, 18, 2, -23 },
  { 587, 14, 23, 18, 2, -23 },
  { 628, 14, 23, 18, 2, -23 },
  { 669, 14, 23, 18, 2, -23 },
  { 710, 14, 23, 18, 2, -23 },
  { 751, 1, 17, 7, 3, -17 },
  { 754, 3, 21, 7, 1, -17 },
  { 762, 14, 15, 18, 2, -19 },
  { 789, 14, 7, 18, 2, -15 },
  { 802, 14, 15, 18, 2, -19 },
  { 829, 11, 23, 13, 1, -23 },
  { 861, 24, 26, 28, 2, -23 },
  { 939, 18, 23, 18, 0, -23 },
  { 991, 15, 23, 20, 3, -23 },
  { 1035, 17, 23, 20, 2, -23 },
  { 1084, 17, 23, 22, 3, -23 },
  { 1133, 13, 23, 18, 3, -23 },
  { 1171, 13, 23, 16, 3, -23 },
  { 1209, 18, 23, 23, 2, -23 },
  { 1261, 16, 23, 23, 3, -23 },
  { 1307, 5, 23, 9, 2, -23 },
  { 1322, 7, 29, 7, -3, -23 },
  { 1348, 15, 23, 18, 3, -23 },
  { 1392, 13, 23, 16, 3, -23 },
  { 1430, 20, 23, 27, 3, -23 },
  { 1488, 16, 23, 22, 3, -23 },
  { 1534, 20, 23, 24, 2, -23 },
  { 1592, 14, 23, 18, 3, -23 },
  { 1633, 20, 28, 24, 2, -23 },
  { 1703, 15, 23, 18, 3, -23 },
  { 1747, 14, 23, 17, 2, -23 },
  { 1788, 16, 23, 16, 0, -23 },
  { 1834, 17, 23, 23, 3, -23 },
  { 1883, 18, 23, 18, 0, -23 },
  { 1935, 26, 23, 28, 1, -23 },
  { 2010, 16, 23, 16, 0, -23 },
  { 2056, 16, 23, 16, 0, -23 },
  { 2102, 16, 23, 19, 1, -23 },
  { 2148, 6, 28, 10, 3, -23 },
  { 2169, 10, 23, 10, 0, -23 },
  { 2198, 6, 28, 10, 1, -23 },
  { 2219, 16, 14, 18, 1, -23 },
  { 2247, 13, 1, 13, 0, 3 },
  { 2249, 6, 6, 8, 1, -25 },
  { 2254, 12, 17, 16, 2, -17 },
  { 2280, 14, 24, 19, 3, -24 },
  { 2322, 12, 17, 15, 2, -17 },
  { 2348, 14, 24, 19, 2, -24 },
  { 2390, 13, 17, 17, 2, -17 },
  { 2418, 11, 24, 9, 0, -24 },
  { 2451, 14, 25, 19, 2, -17 },
  { 2495, 13, 24, 18, 3, -24 },
  { 2534, 2, 23, 7, 2, -23 },
  { 2540, 6, 31, 7, -2, -23 },
  { 2564, 12, 24, 15, 3, -24 },
  { 2600, 1, 24, 7, 3, -24 },
  { 2603, 22, 17, 27, 3, -17 },
  { 2650, 13, 17, 18, 3, -17 },
  { 2678, 14, 17, 18, 2, -17 },
  { 2708, 14, 24, 19, 3, -17 },
  { 2750, 14, 24, 19, 2, -17 },
  { 2792, 8, 17, 12, 3, -17 },
  { 2809, 12, 17, 15, 1, -17 },
  { 2835, 9, 21, 10, 0, -21 },
  { 2859, 12, 17, 18, 3, -17 },
  { 2885, 14, 17, 14, 0, -17 },
  { 2915, 20, 17, 22, 1, -17 },
  { 2958, 13, 17, 15, 1, -17 },
  { 2986, 14, 25, 14, 0, -17 },
  { 3030, 12, 17, 15, 1, -17 },
  { 3056, 9, 28, 11, 1, -23 },
  { 3088, 1, 32, 17, 8, -24 },
  { 3092, 9, 28, 11, 1, -23 },
  { 3124, 14, 3, 18, 2, -13 },
};

const GFXfont NotoSans_Thin32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin32pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_THIN32PT7B_H_
