#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Thin
// Headers: 67

#include "NotoSans_Thin6pt7b.h"
#include "NotoSans_Thin7pt7b.h"
#include "NotoSans_Thin8pt7b.h"
#include "NotoSans_Thin9pt7b.h"
#include "NotoSans_Thin10pt7b.h"
#include "NotoSans_Thin11pt7b.h"
#include "NotoSans_Thin12pt7b.h"
#include "NotoSans_Thin13pt7b.h"
#include "NotoSans_Thin14pt7b.h"
#include "NotoSans_Thin15pt7b.h"
#include "NotoSans_Thin16pt7b.h"
#include "NotoSans_Thin17pt7b.h"
#include "NotoSans_Thin18pt7b.h"
#include "NotoSans_Thin19pt7b.h"
#include "NotoSans_Thin20pt7b.h"
#include "NotoSans_Thin21pt7b.h"
#include "NotoSans_Thin22pt7b.h"
#include "NotoSans_Thin23pt7b.h"
#include "NotoSans_Thin24pt7b.h"
#include "NotoSans_Thin25pt7b.h"
#include "NotoSans_Thin26pt7b.h"
#include "NotoSans_Thin27pt7b.h"
#include "NotoSans_Thin28pt7b.h"
#include "NotoSans_Thin29pt7b.h"
#include "NotoSans_Thin30pt7b.h"
#include "NotoSans_Thin31pt7b.h"
#include "NotoSans_Thin32pt7b.h"
#include "NotoSans_Thin33pt7b.h"
#include "NotoSans_Thin34pt7b.h"
#include "NotoSans_Thin35pt7b.h"
#include "NotoSans_Thin36pt7b.h"
#include "NotoSans_Thin37pt7b.h"
#include "NotoSans_Thin38pt7b.h"
#include "NotoSans_Thin39pt7b.h"
#include "NotoSans_Thin40pt7b.h"
#include "NotoSans_Thin41pt7b.h"
#include "NotoSans_Thin42pt7b.h"
#include "NotoSans_Thin43pt7b.h"
#include "NotoSans_Thin44pt7b.h"
#include "NotoSans_Thin45pt7b.h"
#include "NotoSans_Thin46pt7b.h"
#include "NotoSans_Thin47pt7b.h"
#include "NotoSans_Thin48pt7b.h"
#include "NotoSans_Thin49pt7b.h"
#include "NotoSans_Thin50pt7b.h"
#include "NotoSans_Thin51pt7b.h"
#include "NotoSans_Thin52pt7b.h"
#include "NotoSans_Thin53pt7b.h"
#include "NotoSans_Thin54pt7b.h"
#include "NotoSans_Thin55pt7b.h"
#include "NotoSans_Thin56pt7b.h"
#include "NotoSans_Thin57pt7b.h"
#include "NotoSans_Thin58pt7b.h"
#include "NotoSans_Thin59pt7b.h"
#include "NotoSans_Thin60pt7b.h"
#include "NotoSans_Thin61pt7b.h"
#include "NotoSans_Thin62pt7b.h"
#include "NotoSans_Thin63pt7b.h"
#include "NotoSans_Thin64pt7b.h"
#include "NotoSans_Thin65pt7b.h"
#include "NotoSans_Thin66pt7b.h"
#include "NotoSans_Thin67pt7b.h"
#include "NotoSans_Thin68pt7b.h"
#include "NotoSans_Thin69pt7b.h"
#include "NotoSans_Thin70pt7b.h"
#include "NotoSans_Thin71pt7b.h"
#include "NotoSans_Thin72pt7b.h"
