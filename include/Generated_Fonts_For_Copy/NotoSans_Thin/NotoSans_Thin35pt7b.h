#ifndef _NOTOSANS_THIN35PT7B_H_
#define _NOTOSANS_THIN35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20,
  0x7F, 0xFF, 0xF8, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x01, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0xFF, 0xFF, 0xE0,
  0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04,
  0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x7C, 0x06, 0x4E, 0x21, 0x01, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x04, 0x10, 0x18, 0x40, 0x31, 0x00, 0x34, 0x00, 0x38, 0x00,
  0x58, 0x01, 0x18, 0x04, 0x30, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10,
  0x10, 0x40, 0x41, 0x01, 0x0B, 0xC5, 0xC0, 0x78, 0x00, 0x40, 0x01, 0x00,
  0x3F, 0x00, 0x20, 0x61, 0x00, 0x60, 0x40, 0x80, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x41, 0x00, 0x80, 0x41, 0x00, 0x80, 0x42, 0x00,
  0x80, 0x42, 0x00, 0x80, 0x44, 0x00, 0x80, 0x84, 0xFC, 0x80, 0x89, 0x84,
  0x40, 0x91, 0x02, 0x61, 0x11, 0x02, 0x3E, 0x22, 0x02, 0x00, 0x22, 0x01,
  0x00, 0x42, 0x01, 0x00, 0x42, 0x01, 0x00, 0x82, 0x01, 0x00, 0x82, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x01, 0x02, 0x02, 0x01, 0x02, 0x04, 0x01, 0x84,
  0x0C, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x40, 0x40, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0x01, 0x00,
  0x08, 0x18, 0x00, 0x21, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x00, 0x00, 0xC8,
  0x00, 0x08, 0x20, 0x04, 0x80, 0x80, 0x48, 0x02, 0x02, 0x80, 0x08, 0x14,
  0x00, 0x21, 0x20, 0x00, 0x89, 0x00, 0x02, 0x88, 0x00, 0x08, 0x20, 0x00,
  0xE1, 0x00, 0x08, 0x86, 0x01, 0x82, 0x0F, 0xF0, 0x08, 0xFF, 0x80, 0x06,
  0x18, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0xC1, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x41, 0x0C,
  0x21, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x10, 0x20, 0x5C, 0x47, 0x07, 0xF0, 0x01, 0x00, 0x05, 0x00, 0x11, 0x00,
  0x21, 0x00, 0x82, 0x02, 0x02, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x24, 0x94, 0x92, 0x80, 0xFF, 0x80, 0xF0, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x18, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x07, 0xE0,
  0x02, 0x1C, 0x49, 0x1C, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xE0,
  0x40, 0x21, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x1F, 0xE0, 0xC0,
  0x32, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x0F, 0x01, 0xFF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x40, 0x0C, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x21,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x1F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x7F, 0xF8, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0xFF, 0x02, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x40, 0x18, 0x7F, 0xC0, 0x01, 0xFC, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x47, 0xF0, 0x98, 0x0C, 0xA0, 0x02, 0xC0, 0x02, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x20, 0x02, 0x10, 0x04, 0x18, 0x0C, 0x07, 0xF0, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F,
  0xF0, 0x10, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x20, 0x04, 0x10, 0x18, 0x0C, 0x60, 0x03, 0x80, 0x06,
  0x60, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x60, 0x04, 0x30, 0x08, 0x0F,
  0xF0, 0x0F, 0xE0, 0x30, 0x10, 0x60, 0x08, 0x40, 0x04, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x05, 0x40, 0x06, 0x20, 0x1A, 0x1F, 0xE2, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x7F, 0x80, 0xB8, 0x00, 0x00, 0x00, 0x3C, 0x23, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x22, 0x24, 0x44, 0x48, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x7F, 0x88, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x10, 0x20,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x13, 0x00, 0x7C, 0x02, 0x40, 0x30, 0x60,
  0x48, 0x08, 0x04, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x40, 0x10, 0x18, 0x10,
  0x02, 0x03, 0x02, 0x00, 0x40, 0x60, 0x40, 0x08, 0x0C, 0x08, 0x01, 0x01,
  0x81, 0x00, 0x60, 0x50, 0x20, 0x0C, 0x0A, 0x02, 0x02, 0x81, 0x40, 0x60,
  0xD0, 0x44, 0x07, 0xE1, 0xF0, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00,
  0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x00, 0xFF, 0xF8,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00,
  0x64, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01, 0x80, 0x00, 0x10, 0xFF,
  0xE0, 0x80, 0x18, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x80,
  0x70, 0x80, 0x0C, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x80, 0x10, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x01, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x20, 0x0E, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88,
  0x00, 0xC2, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFA, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x30, 0x03, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x01,
  0x08, 0x00, 0x10, 0x60, 0x01, 0x01, 0xFF, 0xE0, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0xF8, 0x80, 0x06, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x84, 0x00,
  0x88, 0x00, 0x9C, 0x00, 0xA4, 0x00, 0xC2, 0x00, 0x81, 0x00, 0x81, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x08,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x03, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x78, 0x00, 0x05, 0xA0, 0x00,
  0x26, 0x80, 0x00, 0x99, 0x00, 0x02, 0x64, 0x00, 0x11, 0x88, 0x00, 0x46,
  0x20, 0x02, 0x18, 0x80, 0x08, 0x61, 0x00, 0x21, 0x84, 0x01, 0x06, 0x08,
  0x04, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81, 0x81, 0x04, 0x06, 0x04, 0x10,
  0x18, 0x08, 0x40, 0x60, 0x22, 0x01, 0x80, 0x88, 0x06, 0x01, 0x40, 0x18,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06, 0x20, 0x03, 0x10,
  0x01, 0x84, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x30, 0x20, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x01, 0x03, 0x00, 0x41, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x02,
  0x30, 0x01, 0x98, 0x00, 0x4C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x01, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x80, 0x06, 0x04, 0x00,
  0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x01,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10,
  0x40, 0x00, 0xC0, 0x80, 0x06, 0x01, 0x80, 0x30, 0x01, 0xFF, 0x00, 0xFF,
  0x82, 0x01, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x33, 0xFF, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x18, 0x03,
  0x00, 0x80, 0x06, 0x04, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x24,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x24, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x10, 0x40, 0x00, 0xC0, 0x80, 0x06, 0x01, 0x80,
  0x30, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xC1, 0x00,
  0x62, 0x00, 0x24, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x06, 0x1F, 0xF0, 0x20,
  0x20, 0x40, 0x60, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00, 0x88, 0x01,
  0x90, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x02, 0x0F, 0xF8, 0x60, 0x09,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x40, 0x0C, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40, 0x01, 0x0C, 0x00, 0x60, 0xC0,
  0x18, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x00, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x20, 0x04, 0x02,
  0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00,
  0xA0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x14, 0x00,
  0x60, 0x01, 0x40, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x09, 0x00,
  0x22, 0x00, 0x90, 0x02, 0x20, 0x09, 0x00, 0x22, 0x00, 0x88, 0x04, 0x20,
  0x10, 0x80, 0x41, 0x01, 0x08, 0x04, 0x10, 0x10, 0x40, 0x81, 0x01, 0x04,
  0x08, 0x08, 0x20, 0x40, 0x80, 0x82, 0x04, 0x08, 0x08, 0x20, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x04, 0x40, 0x21, 0x00, 0x44, 0x02, 0x20, 0x04, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x02, 0x80, 0x12, 0x00, 0x28, 0x00, 0xC0,
  0x02, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x40, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x58, 0x00, 0x12, 0x00, 0x08, 0x40, 0x06,
  0x10, 0x01, 0x02, 0x00, 0x80, 0x40, 0x60, 0x10, 0x10, 0x02, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xD0, 0x00,
  0x24, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x21, 0x00, 0x08, 0x80, 0x01,
  0x20, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x02, 0x40, 0x02, 0x60, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08,
  0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x01, 0xFF, 0xFC, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x0F, 0x83,
  0x83, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x7F, 0x4C, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x2A, 0x03, 0x4F, 0xE2, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x87, 0xC1, 0x30, 0x62,
  0xC0, 0x25, 0x00, 0x2C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x02, 0xA0, 0x09, 0x60, 0x32, 0x3F, 0x80, 0x03, 0xF0, 0x60, 0x44,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x03, 0xE2, 0x18, 0x24, 0xC0, 0x29,
  0x00, 0x34, 0x00, 0x68, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03,
  0x20, 0x06, 0x60, 0x14, 0x3F, 0xC8, 0x03, 0xC0, 0x18, 0x60, 0xC0, 0x21,
  0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x08, 0x3F, 0xE0, 0x01, 0xE0, 0x61, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3F, 0x8C, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03,
  0xE0, 0x38, 0x24, 0xC0, 0x29, 0x00, 0x34, 0x00, 0x28, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x50, 0x00, 0xA0, 0x03, 0x20, 0x06, 0x20, 0x34, 0x3F, 0xC8, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x80, 0x10,
  0xFF, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x87, 0xC2, 0x60, 0xCA, 0x00, 0xB0, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0xE0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x06, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x14, 0x01, 0x20, 0x19, 0x01, 0x88, 0x08, 0x40,
  0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0xA0, 0x28, 0x81, 0x84, 0x0C, 0x10,
  0x40, 0x42, 0x01, 0x10, 0x08, 0x80, 0x24, 0x00, 0xA0, 0x02, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x98, 0x63, 0x0C, 0xA0, 0x34, 0x02, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x07,
  0xC2, 0x60, 0xCA, 0x00, 0xB0, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0xE0, 0x0C,
  0x18, 0x30, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08, 0x0F, 0xF0, 0x07,
  0xC1, 0x10, 0x62, 0xC0, 0x25, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x02, 0xA0, 0x0D, 0x20, 0x32, 0x3F, 0x84, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xC0, 0x30, 0x64, 0xC0, 0x2B, 0x00, 0x34, 0x00, 0x68,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x20, 0x0A, 0x60, 0x34,
  0x3F, 0x88, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x07, 0xE6, 0x0A, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x00, 0x07, 0xE1, 0xC0, 0xC8, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x9F, 0xF8,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x7F, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x7C, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xD0, 0x05, 0x60, 0x24, 0x7F,
  0x10, 0x80, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x02, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x10, 0x22, 0x04, 0x40, 0x88, 0x21, 0x04, 0x20, 0x82, 0x10,
  0x82, 0x08, 0x41, 0x10, 0x21, 0x04, 0x40, 0x48, 0x11, 0x01, 0x20, 0x28,
  0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x01,
  0x00, 0xC0, 0x0C, 0x40, 0x10, 0x80, 0x40, 0x81, 0x00, 0x82, 0x00, 0x88,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x00, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00,
  0x82, 0x02, 0x06, 0x08, 0x04, 0x10, 0x04, 0x40, 0x05, 0x00, 0x0C, 0x80,
  0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x01, 0x60, 0x01,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x03, 0xC1,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x03, 0x03, 0x00, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xC0,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x06, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x30, 0x07, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x1C, 0x08, 0x00, 0x3E, 0x01, 0xC1,
  0x81, 0x80, 0x7E,
};

const GFXglyph NotoSans_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 25, 8, 3, -25 },
  { 8, 6, 9, 11, 3, -25 },
  { 15, 21, 25, 23, 1, -25 },
  { 81, 14, 29, 20, 2, -27 },
  { 132, 24, 25, 28, 2, -25 },
  { 207, 21, 25, 25, 2, -25 },
  { 273, 1, 9, 6, 3, -25 },
  { 275, 7, 31, 9, 1, -25 },
  { 303, 6, 31, 9, 1, -25 },
  { 327, 15, 15, 19, 2, -27 },
  { 356, 16, 16, 20, 2, -20 },
  { 388, 3, 9, 6, 1, -4 },
  { 392, 9, 1, 11, 1, -10 },
  { 394, 2, 2, 8, 3, -2 },
  { 395, 11, 25, 11, 0, -25 },
  { 430, 16, 25, 20, 2, -25 },
  { 480, 7, 25, 20, 4, -25 },
  { 502, 15, 25, 20, 2, -25 },
  { 549, 15, 25, 20, 2, -25 },
  { 596, 19, 25, 20, 1, -25 },
  { 656, 15, 25, 20, 3, -25 },
  { 703, 16, 25, 20, 2, -25 },
  { 753, 16, 25, 20, 2, -25 },
  { 803, 16, 25, 20, 2, -25 },
  { 853, 16, 25, 20, 2, -25 },
  { 903, 2, 19, 8, 3, -19 },
  { 908, 4, 24, 8, 1, -19 },
  { 920, 16, 16, 20, 2, -21 },
  { 952, 16, 8, 20, 2, -16 },
  { 968, 16, 16, 20, 2, -21 },
  { 1000, 12, 25, 14, 1, -25 },
  { 1038, 27, 29, 31, 2, -25 },
  { 1136, 20, 25, 20, 0, -25 },
  { 1199, 16, 25, 21, 4, -25 },
  { 1249, 18, 25, 21, 2, -25 },
  { 1306, 18, 25, 24, 4, -25 },
  { 1363, 13, 25, 19, 4, -25 },
  { 1404, 13, 25, 17, 4, -25 },
  { 1445, 20, 25, 25, 2, -25 },
  { 1508, 17, 25, 25, 4, -25 },
  { 1562, 6, 25, 10, 2, -25 },
  { 1581, 8, 31, 8, -3, -25 },
  { 1612, 16, 25, 20, 4, -25 },
  { 1662, 13, 25, 18, 4, -25 },
  { 1703, 22, 25, 29, 4, -25 },
  { 1772, 17, 25, 24, 4, -25 },
  { 1826, 22, 25, 26, 2, -25 },
  { 1895, 14, 25, 20, 4, -25 },
  { 1939, 22, 31, 26, 2, -25 },
  { 2025, 15, 25, 20, 4, -25 },
  { 2072, 15, 25, 19, 2, -25 },
  { 2119, 18, 25, 18, 0, -25 },
  { 2176, 19, 25, 25, 3, -25 },
  { 2236, 20, 25, 20, 0, -25 },
  { 2299, 28, 25, 30, 1, -25 },
  { 2387, 18, 25, 18, 0, -25 },
  { 2444, 18, 25, 18, 0, -25 },
  { 2501, 18, 25, 20, 1, -25 },
  { 2558, 7, 31, 11, 3, -25 },
  { 2586, 11, 25, 11, 0, -25 },
  { 2621, 7, 31, 11, 1, -25 },
  { 2649, 16, 15, 20, 2, -25 },
  { 2679, 14, 1, 14, 0, 3 },
  { 2681, 6, 6, 9, 1, -27 },
  { 2686, 13, 19, 18, 2, -19 },
  { 2717, 15, 27, 20, 3, -27 },
  { 2768, 13, 19, 17, 2, -19 },
  { 2799, 15, 27, 20, 2, -27 },
  { 2850, 15, 19, 19, 2, -19 },
  { 2886, 12, 27, 10, 0, -27 },
  { 2927, 15, 27, 20, 2, -19 },
  { 2978, 14, 27, 20, 3, -27 },
  { 3026, 2, 25, 7, 3, -25 },
  { 3033, 7, 33, 7, -2, -25 },
  { 3062, 13, 27, 16, 3, -27 },
  { 3106, 1, 27, 7, 3, -27 },
  { 3110, 24, 19, 30, 3, -19 },
  { 3167, 14, 19, 20, 3, -19 },
  { 3201, 16, 19, 20, 2, -19 },
  { 3239, 15, 27, 20, 3, -19 },
  { 3290, 15, 27, 20, 2, -19 },
  { 3341, 10, 19, 13, 3, -19 },
  { 3365, 13, 19, 16, 1, -19 },
  { 3396, 10, 23, 11, 0, -23 },
  { 3425, 14, 18, 20, 3, -18 },
  { 3457, 15, 18, 15, 0, -18 },
  { 3491, 22, 18, 24, 1, -18 },
  { 3541, 15, 18, 17, 1, -18 },
  { 3575, 15, 27, 15, 0, -18 },
  { 3626, 14, 18, 16, 1, -18 },
  { 3658, 10, 31, 12, 1, -25 },
  { 3697, 1, 36, 19, 9, -27 },
  { 3702, 10, 31, 12, 1, -25 },
  { 3741, 16, 3, 20, 2, -14 },
};

const GFXfont NotoSans_Thin35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin35pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_THIN35PT7B_H_
