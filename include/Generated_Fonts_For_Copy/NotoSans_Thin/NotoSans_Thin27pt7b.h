#ifndef _NOTOSANS_THIN27PT7B_H_
#define _NOTOSANS_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x50, 0x0C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x7F,
  0xFF, 0x04, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF,
  0xFE, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x80, 0x04, 0x00, 0x80, 0xFE, 0x22, 0x28, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x08, 0x80, 0xF0, 0x03, 0x00, 0x58, 0x08, 0x81, 0x08, 0x21, 0x04,
  0x20, 0x84, 0x11, 0x42, 0xC7, 0xE0, 0x08, 0x01, 0x00, 0x30, 0x00, 0x13,
  0x01, 0x08, 0x40, 0x42, 0x08, 0x20, 0x82, 0x10, 0x20, 0x84, 0x08, 0x22,
  0x02, 0x08, 0x80, 0x82, 0x47, 0x20, 0x92, 0x28, 0x49, 0x09, 0x32, 0x41,
  0x31, 0x20, 0x40, 0x88, 0x10, 0x22, 0x04, 0x10, 0x81, 0x04, 0x20, 0x42,
  0x04, 0x10, 0x81, 0x08, 0x40, 0x3C, 0x07, 0x00, 0x18, 0x80, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x40, 0x10, 0x80, 0x0B, 0x00,
  0x0C, 0x00, 0x32, 0x00, 0x41, 0x01, 0x80, 0x82, 0x80, 0x42, 0x80, 0x24,
  0x80, 0x14, 0x80, 0x08, 0x80, 0x14, 0x40, 0x22, 0x3F, 0xC1, 0xFE, 0x18,
  0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x60, 0xC2, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x42, 0x23, 0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x17, 0x5C,
  0x1C, 0x02, 0x80, 0x90, 0x11, 0x04, 0x10, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x55, 0xA0, 0xFE, 0xC0, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x0C, 0x03, 0x18, 0x40, 0x44, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x20, 0x41, 0xF8, 0x0C, 0xD4,
  0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x40, 0x0E, 0x0E, 0x32, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0x0C, 0xC0, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x41, 0xF8, 0x01, 0xC0, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x27, 0xFC, 0x00,
  0x60, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x42, 0x02,
  0x08, 0x10, 0x20, 0x80, 0x82, 0x02, 0x10, 0x08, 0x80, 0x23, 0xFF, 0xF0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x7F, 0xC4, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x05, 0xE0, 0x61, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x28, 0x04,
  0x7F, 0x80, 0x03, 0xC0, 0xC2, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x8F, 0x8B, 0x04, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0xFF, 0xF0, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x00, 0x0E, 0x03, 0x18, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24,
  0x04, 0x31, 0x80, 0xE0, 0x11, 0x86, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x02, 0x40, 0x43, 0xF8, 0x07, 0x00, 0xC6, 0x08, 0x08,
  0x80, 0x44, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x40, 0x1A, 0x00, 0x90,
  0x0A, 0x61, 0x90, 0xF1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00,
  0x24, 0x94, 0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x04, 0x00,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x08, 0x00, 0x2C, 0x61, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x06, 0x02, 0x00, 0x08, 0x20, 0x00,
  0x22, 0x00, 0x01, 0x10, 0x1E, 0x05, 0x03, 0x08, 0x28, 0x20, 0x41, 0x42,
  0x02, 0x0C, 0x10, 0x10, 0x60, 0x80, 0x83, 0x04, 0x04, 0x18, 0x20, 0x20,
  0xC1, 0x01, 0x05, 0x04, 0x18, 0x48, 0x1F, 0x3C, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0xFA, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x1F, 0xF8,
  0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x01, 0xFF, 0xC8, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x04, 0xFF, 0x88, 0x0C, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x04, 0xFF, 0x80, 0x01, 0xA0, 0x38, 0x71, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x03, 0xFE, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x22,
  0x03, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x01, 0x70, 0x1C, 0x1C, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03,
  0xF4, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x40, 0x04, 0x60, 0x08, 0x3F, 0xE0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x82, 0x78, 0x80, 0x38, 0x04, 0x80,
  0x88, 0x10, 0x82, 0x08, 0x40, 0x88, 0x09, 0x00, 0xB0, 0x0C, 0x80, 0x84,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80,
  0x10, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xFC, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xB4, 0x00, 0x5A, 0x00, 0x2D,
  0x00, 0x26, 0x40, 0x13, 0x20, 0x11, 0x88, 0x08, 0xC4, 0x04, 0x62, 0x04,
  0x30, 0x82, 0x18, 0x42, 0x0C, 0x11, 0x06, 0x08, 0x83, 0x04, 0x81, 0x81,
  0x40, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40,
  0x19, 0x00, 0xC8, 0x06, 0x20, 0x30, 0x81, 0x84, 0x0C, 0x10, 0x60, 0x43,
  0x02, 0x18, 0x08, 0xC0, 0x26, 0x01, 0x30, 0x05, 0x80, 0x1C, 0x00, 0x60,
  0x02, 0x02, 0x80, 0x06, 0x1C, 0x04, 0x01, 0x04, 0x00, 0x44, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x02, 0x10, 0x01, 0x04, 0x03, 0x01, 0xFE, 0x00, 0xFF, 0x90, 0x0A, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x33, 0xF0, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x02,
  0x80, 0x06, 0x1C, 0x04, 0x01, 0x04, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x10,
  0x01, 0x04, 0x03, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x38, 0xFE, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x10, 0x0D, 0x06,
  0x1D, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0x00,
  0x1C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x7F, 0xC0, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x40, 0x09, 0x80, 0x41, 0xFE, 0x00, 0x80, 0x02,
  0x80, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x88,
  0x01, 0x10, 0x01, 0x40, 0x02, 0x80, 0x03, 0x00, 0x04, 0x00, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x24, 0x05, 0x00, 0x90, 0x14, 0x02, 0x40, 0x50, 0x11,
  0x01, 0x20, 0x42, 0x08, 0x81, 0x08, 0x22, 0x04, 0x20, 0x84, 0x20, 0x82,
  0x10, 0x81, 0x10, 0x42, 0x04, 0x41, 0x10, 0x11, 0x02, 0x40, 0x28, 0x09,
  0x00, 0xA0, 0x24, 0x02, 0x80, 0x60, 0x0A, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x10, 0x00, 0x40, 0x08, 0x80, 0x42, 0x01, 0x04, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x48, 0x01, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x20,
  0x08, 0x40, 0x41, 0x01, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00, 0x28, 0x00,
  0x40, 0x80, 0x0D, 0x00, 0x24, 0x01, 0x08, 0x04, 0x20, 0x20, 0x40, 0x80,
  0x84, 0x02, 0x10, 0x04, 0x80, 0x14, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F,
  0xF8, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0F, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xE0, 0x03, 0x00, 0x28, 0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x20, 0x40,
  0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x03, 0x00, 0x10, 0xFF, 0xE0, 0x82,
  0x08, 0x20, 0x80, 0x0E, 0x06, 0x30, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x7F, 0x30, 0x28, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x81, 0x4F, 0xC8,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x87, 0x09, 0x8C,
  0xA0, 0x2C, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x2A, 0x04, 0x9F, 0x80, 0x07, 0x06, 0x32, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x18, 0x01, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43,
  0x89, 0x8D, 0x40, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x33, 0xFA, 0x0E, 0x06, 0x31, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x07, 0xF0, 0x07, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x41, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x0E, 0x06, 0x35, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x80,
  0xCF, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x2F, 0xF8, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x21, 0xC4, 0xC6, 0xA0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0xC0, 0x2A, 0xAA, 0xAA, 0xA8, 0x18, 0x00, 0x00, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0xE0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x02, 0x81, 0x20,
  0x88, 0x22, 0x10, 0x88, 0x26, 0x0A, 0x43, 0x10, 0x82, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0x40, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x16, 0x33, 0x13, 0x02,
  0x81, 0x60, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x07, 0x13, 0x1A, 0x80, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x0C, 0x03, 0x18, 0x40, 0x48, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04,
  0x3F, 0x80, 0x07, 0x09, 0x8C, 0xA0, 0x2C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x2A, 0x04, 0x9F,
  0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0E, 0x06,
  0x35, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x80, 0xCF, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x9F, 0xA0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x0E, 0x0C, 0x74, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x70, 0x03, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x2F, 0xF0,
  0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0A,
  0x7E, 0x40, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20,
  0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0xC0,
  0x40, 0x50, 0x30, 0x14, 0x0A, 0x09, 0x02, 0x82, 0x21, 0x20, 0x88, 0x44,
  0x22, 0x11, 0x10, 0x48, 0x44, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x68, 0x08, 0x82, 0x08,
  0x81, 0x20, 0x14, 0x01, 0x00, 0x50, 0x0A, 0x02, 0x20, 0x82, 0x20, 0x44,
  0x05, 0x00, 0x40, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04,
  0x20, 0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0xC0, 0x00, 0x7F,
  0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x3F, 0xF0, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x86, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x30, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x38, 0x00, 0x38, 0x08, 0x63, 0x00, 0xC0,
};

const GFXglyph NotoSans_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 16, 19, 17, 1, -19 },
  { 49, 11, 23, 15, 2, -21 },
  { 81, 18, 20, 21, 2, -20 },
  { 126, 16, 20, 19, 2, -20 },
  { 166, 1, 7, 5, 2, -19 },
  { 167, 5, 23, 7, 1, -19 },
  { 182, 5, 23, 7, 1, -19 },
  { 197, 11, 10, 15, 2, -20 },
  { 211, 13, 13, 15, 1, -16 },
  { 233, 2, 6, 5, 1, -3 },
  { 235, 7, 1, 9, 1, -8 },
  { 236, 2, 1, 6, 2, -1 },
  { 237, 8, 19, 9, 0, -19 },
  { 256, 12, 20, 15, 2, -20 },
  { 286, 6, 19, 15, 3, -19 },
  { 301, 11, 20, 15, 2, -20 },
  { 329, 12, 20, 15, 1, -20 },
  { 359, 14, 19, 15, 1, -19 },
  { 393, 12, 19, 15, 2, -19 },
  { 422, 12, 20, 15, 2, -20 },
  { 452, 12, 19, 15, 2, -19 },
  { 481, 12, 20, 15, 2, -20 },
  { 511, 13, 20, 15, 1, -20 },
  { 544, 2, 14, 6, 2, -14 },
  { 548, 3, 17, 6, 1, -14 },
  { 555, 12, 12, 15, 2, -16 },
  { 573, 13, 7, 15, 1, -13 },
  { 585, 12, 12, 15, 2, -16 },
  { 603, 9, 20, 11, 1, -20 },
  { 626, 21, 22, 24, 1, -19 },
  { 684, 16, 19, 16, 0, -19 },
  { 722, 12, 19, 17, 3, -19 },
  { 751, 14, 20, 17, 2, -20 },
  { 786, 14, 19, 19, 3, -19 },
  { 820, 10, 19, 15, 3, -19 },
  { 844, 10, 19, 13, 3, -19 },
  { 868, 15, 20, 19, 2, -20 },
  { 906, 13, 19, 19, 3, -19 },
  { 937, 4, 19, 8, 2, -19 },
  { 947, 7, 24, 6, -3, -19 },
  { 968, 12, 19, 15, 3, -19 },
  { 997, 10, 19, 14, 3, -19 },
  { 1021, 17, 19, 23, 3, -19 },
  { 1062, 13, 19, 19, 3, -19 },
  { 1093, 17, 20, 20, 2, -20 },
  { 1136, 11, 19, 15, 3, -19 },
  { 1163, 17, 25, 20, 2, -20 },
  { 1217, 12, 19, 16, 3, -19 },
  { 1246, 11, 20, 15, 2, -20 },
  { 1274, 14, 19, 14, 0, -19 },
  { 1308, 14, 19, 19, 3, -19 },
  { 1342, 15, 19, 15, 0, -19 },
  { 1378, 22, 19, 23, 1, -19 },
  { 1431, 14, 19, 14, 0, -19 },
  { 1465, 14, 19, 14, 0, -19 },
  { 1499, 14, 19, 16, 1, -19 },
  { 1533, 6, 23, 8, 2, -19 },
  { 1551, 8, 19, 9, 0, -19 },
  { 1570, 5, 23, 8, 1, -19 },
  { 1585, 13, 12, 15, 1, -19 },
  { 1605, 11, 1, 11, 0, 2 },
  { 1607, 5, 5, 7, 1, -21 },
  { 1611, 11, 15, 14, 1, -15 },
  { 1632, 12, 21, 16, 2, -21 },
  { 1664, 10, 15, 13, 2, -15 },
  { 1683, 11, 21, 16, 2, -21 },
  { 1712, 11, 15, 15, 2, -15 },
  { 1733, 9, 21, 7, 0, -21 },
  { 1757, 11, 21, 16, 2, -15 },
  { 1786, 11, 21, 15, 2, -21 },
  { 1815, 2, 19, 6, 2, -19 },
  { 1820, 5, 25, 6, -1, -19 },
  { 1836, 10, 21, 12, 2, -21 },
  { 1863, 1, 21, 6, 2, -21 },
  { 1866, 19, 15, 23, 2, -15 },
  { 1902, 11, 15, 15, 2, -15 },
  { 1923, 12, 15, 16, 2, -15 },
  { 1946, 12, 21, 16, 2, -15 },
  { 1978, 11, 21, 16, 2, -15 },
  { 2007, 8, 14, 10, 2, -14 },
  { 2021, 10, 15, 12, 1, -15 },
  { 2040, 8, 18, 9, 0, -18 },
  { 2058, 11, 14, 15, 2, -14 },
  { 2078, 12, 14, 12, 0, -14 },
  { 2099, 18, 14, 19, 0, -14 },
  { 2131, 11, 14, 13, 1, -14 },
  { 2151, 12, 21, 12, 0, -14 },
  { 2183, 10, 14, 12, 1, -14 },
  { 2201, 7, 23, 9, 1, -19 },
  { 2222, 1, 28, 14, 7, -21 },
  { 2226, 7, 23, 9, 1, -19 },
  { 2247, 12, 3, 15, 2, -11 },
};

const GFXfont NotoSans_Thin27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin27pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_THIN27PT7B_H_
