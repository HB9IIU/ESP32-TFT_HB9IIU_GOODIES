#ifndef _NOTOSANS_THIN38PT7B_H_
#define _NOTOSANS_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0x3C, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x3F, 0xFF, 0xFC, 0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40,
  0x40, 0x01, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40,
  0x02, 0x02, 0x03, 0xFF, 0xFF, 0xE0, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04,
  0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x80, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03,
  0xE0, 0x1C, 0x9C, 0x20, 0x82, 0x40, 0x80, 0x40, 0x80, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x18, 0x80, 0x06,
  0x80, 0x01, 0xC0, 0x00, 0xB0, 0x00, 0x8C, 0x00, 0x86, 0x00, 0x82, 0x00,
  0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x82, 0x00, 0x82, 0x80,
  0x8C, 0x7C, 0xF8, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x00,
  0x06, 0xC0, 0x02, 0x02, 0x08, 0x01, 0x01, 0x01, 0x00, 0x40, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x00, 0x82, 0x00, 0x80,
  0x20, 0x80, 0x20, 0x08, 0x40, 0x08, 0x06, 0x10, 0x02, 0x01, 0x88, 0x30,
  0x40, 0x42, 0x37, 0x10, 0x11, 0x10, 0x64, 0x04, 0x48, 0x08, 0x82, 0x22,
  0x02, 0x1B, 0x10, 0x80, 0x41, 0x04, 0x20, 0x10, 0x02, 0x18, 0x04, 0x00,
  0x86, 0x01, 0x00, 0x41, 0x80, 0x40, 0x10, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x02, 0x03, 0x01, 0x00, 0x80, 0x80, 0x80, 0x30, 0x20, 0x20, 0x04,
  0x10, 0x10, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x07, 0x70, 0x00, 0x10, 0x10,
  0x00, 0x40, 0x10, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x08, 0x02, 0x00, 0x18, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x11, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x10, 0x00, 0x0C,
  0x10, 0x01, 0x20, 0x10, 0x04, 0x80, 0x10, 0x09, 0x00, 0x10, 0x12, 0x00,
  0x10, 0x48, 0x00, 0x10, 0x90, 0x00, 0x12, 0x20, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x40, 0x00, 0xD0, 0x40, 0x03, 0x10, 0x40, 0x18, 0x10, 0x7F, 0xE0,
  0x10, 0xFF, 0xC0, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x20, 0x41, 0x82, 0x04, 0xC0, 0x40, 0x80, 0x81, 0x81, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x41, 0x82, 0x08, 0x10, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x81, 0x70, 0x87, 0x0E,
  0xB8, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08,
  0x18, 0x18, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0xFF,
  0x80, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x03, 0xBC, 0x02,
  0x01, 0x02, 0x00, 0x42, 0x00, 0x31, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x40, 0x02, 0x20, 0x02,
  0x08, 0x01, 0x02, 0x03, 0x00, 0xFF, 0x00, 0x03, 0x07, 0x09, 0x31, 0x61,
  0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80,
  0x07, 0xB8, 0x0C, 0x02, 0x08, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x80,
  0x0F, 0xBC, 0x18, 0x01, 0x10, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x30, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02,
  0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x10, 0x20, 0x02,
  0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x02, 0x03,
  0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x0F, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x40, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0xC0, 0x18, 0x7F, 0xE0,
  0x00, 0x70, 0x01, 0xC3, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x7C, 0x08, 0xC3, 0x85, 0x80, 0x23, 0x80, 0x09, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x14, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x60, 0x02, 0x10, 0x03, 0x06, 0x03, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x07, 0xBC, 0x06, 0x01, 0x84, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x20, 0x01, 0x10, 0x01, 0x84, 0x01, 0x81, 0x01, 0x80,
  0x63, 0x00, 0x0E, 0x00, 0x18, 0xC0, 0x30, 0x18, 0x30, 0x02, 0x30, 0x00,
  0x90, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x01, 0x10, 0x01, 0x84, 0x01, 0x81, 0xFF, 0x00, 0x00, 0x80,
  0x07, 0xB8, 0x04, 0x03, 0x04, 0x00, 0xC4, 0x00, 0x22, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14,
  0x00, 0x1A, 0x00, 0x0D, 0x80, 0x0A, 0x60, 0x19, 0x0E, 0x78, 0x80, 0x40,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32,
  0x22, 0x24, 0x44, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x02, 0x07, 0xEE, 0x10, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x02, 0x60, 0x0F,
  0xF8, 0x0A, 0x00, 0x80, 0x40, 0x50, 0x08, 0x02, 0x03, 0x80, 0x80, 0x10,
  0x18, 0x04, 0x00, 0x80, 0xC0, 0x40, 0x08, 0x06, 0x02, 0x00, 0x40, 0x30,
  0x10, 0x02, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x04, 0x00, 0x80, 0x60, 0x20,
  0x04, 0x03, 0x01, 0x00, 0x50, 0x28, 0x04, 0x02, 0x81, 0x20, 0x10, 0x66,
  0x31, 0x00, 0x7C, 0x0F, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x80, 0x01, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x20, 0x01, 0x01,
  0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x40, 0xFF, 0xF0, 0x40, 0x06, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x90, 0x01, 0x8F, 0xFF, 0x04, 0x00, 0xE2, 0x00, 0x09, 0x00, 0x02, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x02, 0x80, 0x02, 0x40, 0x06, 0x3F, 0xFC, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xBE, 0x03, 0x00, 0x10, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x0F, 0xFE, 0xFF, 0xF0, 0x08,
  0x01, 0xC0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80, 0x06, 0x08,
  0x01, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xE3, 0xE0, 0x30, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x04, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10, 0x30,
  0x00, 0xC0, 0x3F, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0xCE, 0x18, 0x00, 0x80, 0x01, 0xC0,
  0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01,
  0x01, 0x00, 0x81, 0x00, 0x41, 0x00, 0x21, 0x00, 0x11, 0x80, 0x09, 0x60,
  0x05, 0x10, 0x03, 0x04, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x08, 0x10, 0x06, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x11, 0x00, 0x0C,
  0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x05, 0xA0, 0x00, 0x05, 0xA0, 0x00, 0x0D, 0x90, 0x00,
  0x09, 0x90, 0x00, 0x09, 0x88, 0x00, 0x11, 0x88, 0x00, 0x11, 0x88, 0x00,
  0x21, 0x84, 0x00, 0x21, 0x84, 0x00, 0x21, 0x82, 0x00, 0x41, 0x82, 0x00,
  0x41, 0x82, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81, 0x01, 0x81, 0x80, 0x81,
  0x01, 0x80, 0x81, 0x01, 0x80, 0xC2, 0x01, 0x80, 0x42, 0x01, 0x80, 0x46,
  0x01, 0x80, 0x24, 0x01, 0x80, 0x24, 0x01, 0x80, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD0,
  0x00, 0x19, 0x00, 0x03, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x01, 0x86,
  0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x18, 0x08, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x01, 0x01, 0x80, 0x10, 0x30, 0x03, 0x06, 0x00,
  0x20, 0xC0, 0x02, 0x18, 0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0x4C, 0x00,
  0x0D, 0x80, 0x00, 0xB0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xF3, 0xC0, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x10, 0x00, 0x04, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x10, 0x00, 0x04, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x10, 0x03, 0x00, 0x60, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x80,
  0x18, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x18, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF3, 0xC0, 0x02, 0x00, 0x20,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x08, 0x10, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x10, 0x00, 0x04, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x60,
  0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0xFF, 0xE0, 0x40,
  0x0C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00,
  0x84, 0x01, 0x83, 0xFF, 0x01, 0x00, 0x80, 0x80, 0x60, 0x40, 0x10, 0x20,
  0x04, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x62, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x9F, 0x04,
  0x00, 0x44, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x20, 0x03, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x83,
  0x00, 0x60, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00,
  0x04, 0x80, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x82,
  0x00, 0x0C, 0x10, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x20, 0x10, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x60, 0x02,
  0x02, 0x00, 0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x44, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x02, 0x80, 0x06, 0x00, 0x09,
  0x00, 0x0A, 0x00, 0x12, 0x00, 0x14, 0x00, 0x22, 0x00, 0x28, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20, 0x04, 0x10,
  0x04, 0x40, 0x18, 0x20, 0x10, 0x40, 0x20, 0x40, 0x20, 0x80, 0x40, 0x80,
  0x41, 0x00, 0x80, 0x81, 0x02, 0x02, 0x01, 0x02, 0x02, 0x04, 0x02, 0x04,
  0x04, 0x08, 0x02, 0x08, 0x08, 0x30, 0x04, 0x20, 0x08, 0x40, 0x08, 0x40,
  0x10, 0x80, 0x10, 0x80, 0x21, 0x00, 0x11, 0x00, 0x44, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x48, 0x00, 0x90, 0x00, 0x90, 0x01, 0x60, 0x00, 0xE0, 0x02,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x02, 0x08, 0x00, 0x80, 0x80,
  0x10, 0x18, 0x04, 0x01, 0x01, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x23,
  0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28,
  0x00, 0x0C, 0x80, 0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x10, 0x02, 0x03,
  0x00, 0x80, 0x20, 0x30, 0x02, 0x04, 0x00, 0x61, 0x00, 0x04, 0x20, 0x00,
  0x48, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x80, 0x00, 0x28, 0x00, 0x09, 0x80,
  0x01, 0x10, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02, 0x02, 0x00, 0xC0, 0x40,
  0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x11,
  0x00, 0x03, 0x20, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x04, 0x06,
  0x01, 0x01, 0x00, 0x20, 0x80, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x0A, 0x00, 0x03, 0xFF, 0xFE, 0x81, 0x02, 0x0C, 0x08, 0x10, 0x1F, 0xF0,
  0x80, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x1F, 0xF1, 0x80, 0x58, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0F, 0x00, 0x54, 0x02, 0x4F, 0xF1, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x43, 0xFC, 0x26, 0x01, 0x16, 0x00, 0x4A, 0x00,
  0x16, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x02,
  0xC0, 0x01, 0x50, 0x01, 0x28, 0x01, 0x93, 0x01, 0x88, 0xFF, 0x00, 0x03,
  0xFE, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x08, 0x3F,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x83, 0xFC, 0x46, 0x01,
  0x26, 0x00, 0x52, 0x00, 0x2A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x01, 0x48, 0x00, 0xA3, 0x00,
  0x90, 0xFF, 0x88, 0x07, 0xF8, 0x18, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x02, 0x07, 0xFC, 0x01, 0xF8, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x07, 0xFE, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x8C, 0x02, 0x4C,
  0x00, 0xA4, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x03, 0x20, 0x02, 0x98, 0x01, 0x46, 0x03, 0x21,
  0xFF, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x8E, 0x01, 0x81, 0xFF, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x87, 0xF8, 0x98, 0x0C, 0xA0, 0x06, 0xA0, 0x02, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF0, 0x02, 0xAA, 0xAA, 0xAA,
  0xAA, 0xA8, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x37, 0xC0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x38, 0x01, 0x20, 0x08, 0x80, 0x42, 0x03, 0x08, 0x18,
  0x20, 0xC0, 0x82, 0x02, 0x10, 0x08, 0xE0, 0x24, 0x80, 0xA1, 0x03, 0x02,
  0x08, 0x0C, 0x20, 0x10, 0x80, 0x22, 0x00, 0x48, 0x01, 0xA0, 0x02, 0x80,
  0x04, 0xFF, 0xFF, 0xFF, 0xF8, 0x8F, 0xE0, 0xFF, 0x24, 0x04, 0x60, 0x6A,
  0x00, 0xA0, 0x0F, 0x00, 0x28, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00,
  0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60,
  0x01, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x87, 0xF8,
  0x98, 0x0C, 0xA0, 0x06, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x07, 0xF8, 0x06, 0x01, 0x83, 0x00, 0x30, 0x80, 0x04, 0x40,
  0x01, 0x90, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x06, 0x20, 0x01, 0x0C, 0x00, 0x81, 0x80, 0x40, 0x1F, 0xE0, 0x87,
  0xF8, 0x4C, 0x02, 0x24, 0x00, 0x94, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x05, 0x80, 0x02, 0xA0, 0x03, 0x58,
  0x01, 0x26, 0x03, 0x10, 0xFF, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x8C, 0x02, 0x4C, 0x00, 0xA4, 0x00, 0x54, 0x00, 0x1A,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x60,
  0x02, 0x90, 0x03, 0x44, 0x03, 0x21, 0xFE, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x8F, 0xF2, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x0F, 0xFC, 0x60, 0x08, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x0B, 0x00, 0x21, 0xFF, 0x80, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x01, 0xFF, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x07, 0xE0, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x40, 0x06, 0x80, 0x14, 0x80, 0x48, 0xFF, 0x10, 0x80, 0x01,
  0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x30,
  0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x00, 0x80, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x60, 0x22, 0x02, 0x20,
  0x42, 0x04, 0x20, 0x43, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x04, 0x10,
  0x81, 0x08, 0x10, 0x80, 0x88, 0x09, 0x00, 0x88, 0x09, 0x00, 0x88, 0x09,
  0x00, 0x50, 0x0A, 0x00, 0x50, 0x06, 0x00, 0x50, 0x06, 0x00, 0x20, 0x04,
  0x00, 0x20, 0xC0, 0x03, 0x60, 0x06, 0x20, 0x04, 0x10, 0x08, 0x08, 0x10,
  0x0C, 0x30, 0x04, 0x20, 0x02, 0x40, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x04, 0x60, 0x04, 0x20, 0x08, 0x10, 0x10, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x40, 0x01, 0x40, 0x02,
  0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x01, 0xC1, 0x80, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xC0, 0xE0,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x00, 0xE0, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0xF0, 0x00,
  0x3F, 0x00, 0x70, 0x30, 0x28, 0x03, 0xF0,
};

const GFXglyph NotoSans_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 6, 10, 12, 3, -27 },
  { 16, 22, 27, 25, 1, -27 },
  { 91, 16, 31, 22, 2, -29 },
  { 153, 26, 28, 30, 2, -28 },
  { 244, 23, 28, 27, 2, -28 },
  { 325, 1, 10, 7, 3, -27 },
  { 327, 6, 33, 10, 2, -27 },
  { 352, 7, 33, 10, 1, -27 },
  { 381, 16, 15, 21, 2, -29 },
  { 411, 18, 17, 22, 2, -22 },
  { 450, 4, 9, 7, 1, -4 },
  { 455, 9, 1, 12, 2, -11 },
  { 457, 2, 2, 8, 3, -2 },
  { 458, 12, 27, 12, 0, -27 },
  { 499, 17, 28, 22, 2, -28 },
  { 559, 8, 27, 22, 4, -27 },
  { 586, 17, 28, 22, 2, -28 },
  { 646, 17, 28, 22, 2, -28 },
  { 706, 20, 27, 22, 1, -27 },
  { 774, 16, 27, 22, 3, -27 },
  { 828, 17, 28, 22, 3, -28 },
  { 888, 17, 27, 22, 2, -27 },
  { 946, 17, 28, 22, 2, -28 },
  { 1006, 17, 28, 22, 2, -28 },
  { 1066, 2, 20, 8, 3, -20 },
  { 1071, 4, 25, 8, 1, -20 },
  { 1084, 18, 17, 22, 2, -22 },
  { 1123, 18, 9, 22, 2, -18 },
  { 1144, 18, 17, 22, 2, -22 },
  { 1183, 13, 28, 16, 1, -28 },
  { 1229, 29, 31, 33, 2, -27 },
  { 1342, 22, 27, 22, 0, -27 },
  { 1417, 17, 27, 23, 4, -27 },
  { 1475, 20, 28, 23, 2, -28 },
  { 1545, 20, 27, 26, 4, -27 },
  { 1613, 15, 27, 21, 4, -27 },
  { 1664, 15, 27, 19, 4, -27 },
  { 1715, 22, 28, 27, 2, -28 },
  { 1792, 19, 27, 27, 4, -27 },
  { 1857, 6, 27, 11, 2, -27 },
  { 1878, 9, 34, 9, -4, -27 },
  { 1917, 17, 27, 21, 4, -27 },
  { 1975, 14, 27, 19, 4, -27 },
  { 2023, 24, 27, 32, 4, -27 },
  { 2104, 19, 27, 27, 4, -27 },
  { 2169, 24, 28, 29, 2, -28 },
  { 2253, 16, 27, 22, 4, -27 },
  { 2307, 24, 34, 29, 2, -28 },
  { 2409, 17, 27, 22, 4, -27 },
  { 2467, 17, 28, 21, 2, -28 },
  { 2527, 19, 27, 19, 0, -27 },
  { 2592, 19, 27, 27, 4, -27 },
  { 2657, 21, 27, 21, 0, -27 },
  { 2728, 31, 27, 33, 1, -27 },
  { 2833, 19, 27, 19, 0, -27 },
  { 2898, 19, 27, 19, 0, -27 },
  { 2963, 19, 27, 22, 1, -27 },
  { 3028, 8, 33, 12, 3, -27 },
  { 3061, 12, 27, 12, 0, -27 },
  { 3102, 8, 33, 12, 1, -27 },
  { 3135, 18, 16, 22, 2, -27 },
  { 3171, 15, 1, 15, 0, 3 },
  { 3173, 6, 6, 9, 2, -29 },
  { 3178, 14, 20, 19, 2, -20 },
  { 3213, 17, 29, 22, 3, -29 },
  { 3275, 15, 20, 18, 2, -20 },
  { 3313, 17, 29, 22, 2, -29 },
  { 3375, 16, 20, 21, 2, -20 },
  { 3415, 13, 29, 10, 0, -29 },
  { 3463, 17, 29, 22, 2, -20 },
  { 3525, 16, 29, 22, 3, -29 },
  { 3583, 2, 27, 8, 3, -27 },
  { 3590, 7, 36, 8, -2, -27 },
  { 3622, 14, 29, 17, 3, -29 },
  { 3673, 1, 29, 8, 3, -29 },
  { 3677, 26, 20, 32, 3, -20 },
  { 3742, 16, 20, 22, 3, -20 },
  { 3782, 18, 20, 22, 2, -20 },
  { 3827, 17, 29, 22, 3, -20 },
  { 3889, 17, 29, 22, 2, -20 },
  { 3951, 11, 20, 14, 3, -20 },
  { 3979, 15, 20, 17, 1, -20 },
  { 4017, 11, 25, 12, 0, -25 },
  { 4052, 15, 20, 22, 3, -20 },
  { 4090, 16, 20, 16, 0, -20 },
  { 4130, 24, 20, 26, 1, -20 },
  { 4190, 16, 20, 18, 1, -20 },
  { 4230, 16, 29, 16, 0, -20 },
  { 4288, 14, 20, 17, 2, -20 },
  { 4323, 10, 33, 13, 1, -27 },
  { 4365, 1, 39, 20, 10, -29 },
  { 4370, 11, 33, 13, 1, -27 },
  { 4416, 18, 3, 22, 2, -15 },
};

const GFXfont NotoSans_Thin38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin38pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_THIN38PT7B_H_
