#ifndef _NOTOSANS_THIN70PT7B_H_
#define _NOTOSANS_THIN70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00,
  0x6E, 0xFE, 0x40, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0x7F, 0xC0, 0x1E, 0x08, 0x0F,
  0x81, 0xC0, 0x40, 0x08, 0x18, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30, 0x01,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x70, 0x08, 0x00, 0x01, 0xC0,
  0x40, 0x00, 0x03, 0x82, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x3C, 0x00,
  0x00, 0x08, 0x78, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x02, 0x01, 0xC0, 0x00,
  0x10, 0x07, 0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x20,
  0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x03,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x40, 0x1C, 0x40, 0x02, 0x03, 0xC3, 0xC0, 0x10, 0x78,
  0x1F, 0xFE, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0C, 0x07, 0xF8, 0x18,
  0x00, 0x18, 0x18, 0x3C, 0x3C, 0x30, 0x00, 0x30, 0x60, 0xE0, 0x18, 0x60,
  0x00, 0xC0, 0xC1, 0x80, 0x18, 0x60, 0x01, 0x83, 0x06, 0x00, 0x18, 0xC0,
  0x06, 0x06, 0x0C, 0x00, 0x31, 0xC0, 0x0C, 0x18, 0x30, 0x00, 0x61, 0xC0,
  0x30, 0x60, 0x60, 0x00, 0x61, 0xC1, 0xC0, 0xC0, 0xC0, 0x00, 0xC1, 0xFF,
  0x03, 0x01, 0x00, 0x01, 0x80, 0x70, 0x06, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x38, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x80, 0x00, 0x61, 0x80, 0x00, 0x38, 0x00, 0x08,
  0x30, 0x00, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x61, 0x80,
  0x00, 0x03, 0x80, 0x18, 0x30, 0x00, 0x00, 0x38, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0xC1, 0x80, 0x00, 0x00, 0x38, 0x18, 0x30, 0x00, 0x00, 0x03,
  0x86, 0x06, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x40, 0x00, 0x00, 0x03, 0xB0,
  0x0C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x33, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x30, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x30, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x30, 0x01, 0xFF, 0x00, 0xC0, 0x3F, 0x0F, 0x83, 0x07, 0xC0, 0x03, 0xC4,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x80, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x61,
  0x8C, 0x30, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x6E, 0xFE, 0x40, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0xE8, 0x03, 0x90, 0x0E, 0x20, 0x70, 0x41, 0xC0, 0x8F, 0x01,
  0x38, 0x02, 0xE0, 0x07, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x70, 0xF8, 0x00, 0x01, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x04,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x18, 0x0F, 0xFF, 0xC0, 0x30, 0x7C,
  0x03, 0xE0, 0x61, 0xC0, 0x00, 0xE0, 0xC6, 0x00, 0x00, 0x61, 0x98, 0x00,
  0x00, 0x63, 0x60, 0x00, 0x00, 0x67, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x1E, 0x60, 0x00, 0x00, 0x6C, 0x60, 0x00, 0x01, 0x98, 0x60, 0x00,
  0x0E, 0x30, 0xF0, 0x00, 0x38, 0x60, 0x78, 0x03, 0xC0, 0xC0, 0x3F, 0xFE,
  0x01, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x20,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xEF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0xEF, 0xE4, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xF0, 0x0F, 0x86, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x19,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x66, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x98, 0x00, 0x18, 0x00, 0x03, 0x00, 0x02, 0x40, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x02, 0x00, 0x03, 0xC0,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x2C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xB0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x1B,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x4C, 0x00, 0x18, 0x00, 0x02, 0x80,
  0x03, 0x30, 0x00, 0x60, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00,
  0x4C, 0x00, 0x61, 0x00, 0x03, 0x80, 0x03, 0x30, 0x03, 0x86, 0x00, 0x07,
  0x00, 0x38, 0x60, 0x1C, 0x18, 0x00, 0x0F, 0x07, 0xC0, 0xE3, 0xE0, 0x60,
  0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x01, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xD8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xF7, 0xFC, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3F, 0xCF, 0xFF, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x80, 0x38, 0xFF, 0xF0, 0x7F,
  0xC0, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC1, 0xB0, 0x00, 0x00, 0xC3, 0x38, 0x00,
  0x00, 0xC6, 0x18, 0x00, 0x00, 0xCC, 0x0C, 0x00, 0x00, 0xD8, 0x06, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x00,
  0x00, 0xDD, 0x80, 0x00, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x00, 0x01,
  0xBC, 0xC0, 0x00, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x00, 0x03, 0x3C,
  0x60, 0x00, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x00, 0x06, 0x3C, 0x30,
  0x00, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x3C, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x3C, 0x18, 0x00, 0x00,
  0x01, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x3C, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x3C, 0x06, 0x00, 0x00, 0x02, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x60, 0x3C, 0x03, 0x00, 0x00, 0x06, 0x03, 0xC0,
  0x30, 0x00, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x3C, 0x00, 0x60, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x3C, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x3C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x3C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x04, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x00, 0xF3,
  0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x18,
  0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00,
  0x00, 0x37, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x07, 0xC1, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x78, 0x30, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xC0, 0xF8, 0x07, 0x80, 0x03, 0x80, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x30, 0x7C, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x03, 0x6E, 0x00, 0x00,
  0xCC, 0xC0, 0x00, 0x39, 0x8E, 0x00, 0x0E, 0x30, 0xF0, 0x0F, 0x06, 0x0F,
  0xFF, 0x80, 0xC0, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x03, 0xE0, 0x00, 0xC0, 0x7F, 0xFC, 0x01,
  0x83, 0xE0, 0x1E, 0x03, 0x0E, 0x00, 0x0E, 0x06, 0x38, 0x00, 0x06, 0x0C,
  0xC0, 0x00, 0x06, 0x1B, 0x80, 0x00, 0x06, 0x36, 0x00, 0x00, 0x0C, 0x78,
  0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01,
  0x9E, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x0C, 0x6C, 0x00, 0x00, 0x30,
  0xCC, 0x00, 0x00, 0xE1, 0x9C, 0x00, 0x03, 0x83, 0x1C, 0x00, 0x1E, 0x06,
  0x0F, 0x00, 0xF0, 0x0C, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x70,
  0x00, 0x10, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x10, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x03, 0x00, 0x3F, 0xFC, 0x06, 0x01, 0xF0, 0x1E, 0x0C, 0x0F, 0x00,
  0x0E, 0x18, 0x38, 0x00, 0x06, 0x30, 0xE0, 0x00, 0x06, 0x61, 0x80, 0x00,
  0x06, 0xC6, 0x00, 0x00, 0x0D, 0x98, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0x1E, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x03, 0xCC, 0x00,
  0x00, 0x0D, 0x8C, 0x00, 0x00, 0x1B, 0x0C, 0x00, 0x00, 0x66, 0x1C, 0x00,
  0x01, 0x8C, 0x1E, 0x00, 0x0E, 0x18, 0x0F, 0x80, 0x78, 0x30, 0x07, 0xFF,
  0xC0, 0x60, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x0C, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x10, 0x0F, 0x80, 0xF0, 0x40, 0xE0, 0x00, 0x71,
  0x07, 0x00, 0x00, 0xE4, 0x38, 0x00, 0x01, 0x90, 0xC0, 0x00, 0x03, 0x46,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0x4E, 0x00, 0x00, 0x0D, 0x18, 0x00, 0x00,
  0x34, 0x30, 0x00, 0x01, 0x90, 0x60, 0x00, 0x0C, 0x40, 0xE0, 0x00, 0xE1,
  0x01, 0xF0, 0x1F, 0x04, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x7C, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x7F, 0xFC, 0x0C,
  0x1F, 0x01, 0xF0, 0xC3, 0x80, 0x03, 0x8C, 0x60, 0x00, 0x1C, 0xCC, 0x00,
  0x00, 0xCD, 0x80, 0x00, 0x06, 0xD0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x7F, 0x76, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x38, 0x03, 0xC0, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x81, 0xC7, 0xFC, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x7C, 0x00, 0x0C, 0x33,
  0x00, 0x03, 0x18, 0x60, 0x00, 0xCC, 0x0C, 0x00, 0x36, 0x03, 0x80, 0x0F,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0xC3, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0xC7, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0xCC, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0xD8, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xF0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x0C, 0x07, 0xFF, 0xC0, 0xC1, 0xF0,
  0x1F, 0x0C, 0x38, 0x00, 0x38, 0xC6, 0x00, 0x01, 0xCC, 0xC0, 0x00, 0x0C,
  0xD8, 0x00, 0x00, 0x6D, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x7F, 0xF8, 0x03,
  0x03, 0xC0, 0x7C, 0x06, 0x1E, 0x00, 0x1C, 0x0C, 0x70, 0x00, 0x0C, 0x19,
  0xC0, 0x00, 0x0C, 0x33, 0x00, 0x00, 0x0C, 0x6C, 0x00, 0x00, 0x1C, 0xD8,
  0x00, 0x00, 0x19, 0xE0, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x03,
  0x3C, 0x00, 0x00, 0x06, 0x6C, 0x00, 0x00, 0x18, 0xDC, 0x00, 0x00, 0x71,
  0x98, 0x00, 0x01, 0xC3, 0x18, 0x00, 0x07, 0x06, 0x1C, 0x00, 0x1C, 0x0C,
  0x1F, 0x01, 0xF0, 0x18, 0x0F, 0xFF, 0x80, 0x30, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x1F, 0x01, 0xF0, 0x40, 0xE0, 0x00,
  0xE1, 0x07, 0x00, 0x00, 0xC4, 0x38, 0x00, 0x01, 0x91, 0xC0, 0x00, 0x03,
  0x46, 0x00, 0x00, 0x0D, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x4C, 0x00, 0x00, 0x0D, 0x18, 0x00,
  0x00, 0x64, 0x70, 0x00, 0x03, 0x90, 0xE0, 0x00, 0x1C, 0x41, 0xC0, 0x00,
  0xE1, 0x03, 0xE0, 0x1E, 0x04, 0x03, 0xFF, 0xE0, 0x10, 0x01, 0xFC, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x04, 0x18,
  0x1F, 0xFF, 0x0F, 0x81, 0xE3, 0x80, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x36,
  0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7C,
  0x03, 0xF8, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x38, 0xFE, 0x00, 0x7C, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x02, 0x00, 0xFF,
  0xC0, 0x03, 0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x60, 0x00, 0x00, 0xB6, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x03, 0x33, 0x80,
  0x00, 0x63, 0x1C, 0x00, 0x1C, 0x30, 0xF8, 0x0F, 0x83, 0x03, 0xFF, 0xE0,
  0x30, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x44, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x31, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xE0, 0x06, 0x80, 0x00, 0x7C, 0x3C, 0x80, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 51, 16, 6, -50 },
  { 27, 12, 18, 22, 5, -50 },
  { 54, 41, 50, 45, 2, -50 },
  { 311, 29, 57, 40, 4, -53 },
  { 518, 47, 52, 56, 4, -51 },
  { 824, 43, 52, 49, 4, -51 },
  { 1104, 2, 18, 12, 5, -50 },
  { 1109, 12, 61, 18, 3, -50 },
  { 1201, 12, 61, 18, 3, -50 },
  { 1293, 30, 28, 39, 4, -53 },
  { 1398, 32, 32, 40, 4, -41 },
  { 1526, 6, 17, 13, 3, -8 },
  { 1539, 17, 2, 23, 3, -20 },
  { 1544, 4, 5, 15, 6, -4 },
  { 1547, 21, 50, 23, 1, -50 },
  { 1679, 31, 52, 40, 4, -51 },
  { 1881, 15, 50, 40, 7, -50 },
  { 1975, 30, 51, 40, 4, -51 },
  { 2167, 31, 52, 40, 3, -51 },
  { 2369, 37, 50, 40, 2, -50 },
  { 2601, 30, 51, 40, 5, -50 },
  { 2793, 31, 52, 40, 5, -51 },
  { 2995, 32, 50, 40, 4, -50 },
  { 3195, 31, 52, 40, 4, -51 },
  { 3397, 31, 52, 40, 4, -51 },
  { 3599, 4, 38, 15, 6, -37 },
  { 3618, 7, 46, 15, 3, -37 },
  { 3659, 32, 31, 40, 4, -41 },
  { 3783, 32, 16, 40, 4, -33 },
  { 3847, 32, 31, 40, 4, -41 },
  { 3971, 23, 52, 29, 3, -51 },
  { 4121, 54, 56, 61, 4, -49 },
  { 4499, 40, 50, 40, 0, -50 },
  { 4749, 32, 50, 43, 7, -50 },
  { 4949, 37, 52, 43, 4, -51 },
  { 5190, 37, 50, 48, 7, -50 },
  { 5422, 27, 50, 39, 7, -50 },
  { 5591, 27, 50, 34, 7, -50 },
  { 5760, 41, 52, 50, 4, -51 },
  { 6027, 35, 50, 49, 7, -50 },
  { 6246, 12, 50, 20, 4, -50 },
  { 6321, 16, 62, 16, -7, -50 },
  { 6445, 32, 50, 39, 7, -50 },
  { 6645, 27, 50, 35, 7, -50 },
  { 6814, 44, 50, 59, 7, -50 },
  { 7089, 35, 50, 49, 7, -50 },
  { 7308, 44, 52, 53, 4, -51 },
  { 7594, 29, 50, 40, 7, -50 },
  { 7776, 44, 63, 53, 4, -51 },
  { 8123, 32, 50, 40, 7, -50 },
  { 8323, 30, 52, 38, 4, -51 },
  { 8518, 35, 50, 35, 0, -50 },
  { 8737, 36, 51, 50, 7, -50 },
  { 8967, 39, 50, 39, 0, -50 },
  { 9211, 57, 50, 61, 2, -50 },
  { 9568, 36, 50, 36, 0, -50 },
  { 9793, 35, 50, 35, 0, -50 },
  { 10012, 35, 50, 40, 3, -50 },
  { 10231, 14, 61, 22, 6, -50 },
  { 10338, 21, 50, 23, 1, -50 },
  { 10470, 14, 61, 22, 2, -50 },
  { 10577, 34, 31, 40, 3, -50 },
  { 10709, 28, 2, 27, 0, 6 },
  { 10716, 12, 12, 17, 3, -54 },
  { 10734, 27, 39, 36, 3, -38 },
  { 10866, 31, 54, 41, 6, -53 },
  { 11076, 27, 39, 33, 4, -38 },
  { 11208, 31, 54, 41, 4, -53 },
  { 11418, 30, 39, 38, 4, -38 },
  { 11565, 23, 54, 19, 1, -54 },
  { 11721, 30, 55, 41, 4, -38 },
  { 11928, 28, 53, 40, 6, -53 },
  { 12114, 4, 50, 14, 5, -50 },
  { 12139, 13, 67, 14, -4, -50 },
  { 12248, 26, 53, 32, 6, -53 },
  { 12421, 2, 53, 14, 6, -53 },
  { 12435, 48, 38, 60, 6, -38 },
  { 12663, 28, 38, 40, 6, -38 },
  { 12796, 32, 39, 40, 4, -38 },
  { 12952, 31, 54, 41, 6, -38 },
  { 13162, 30, 54, 41, 4, -38 },
  { 13365, 19, 38, 26, 6, -38 },
  { 13456, 26, 39, 32, 3, -38 },
  { 13583, 19, 47, 22, 1, -46 },
  { 13695, 28, 38, 40, 6, -37 },
  { 13828, 30, 37, 30, 0, -37 },
  { 13967, 46, 37, 48, 1, -37 },
  { 14180, 29, 37, 34, 2, -37 },
  { 14315, 30, 54, 30, 0, -37 },
  { 14518, 26, 37, 32, 3, -37 },
  { 14639, 19, 61, 24, 2, -50 },
  { 14784, 1, 71, 37, 18, -53 },
  { 14793, 19, 61, 24, 3, -50 },
  { 14938, 32, 6, 40, 4, -28 },
};

const GFXfont NotoSans_Thin70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin70pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_THIN70PT7B_H_
