#ifndef _NOTOSANS_THIN49PT7B_H_
#define _NOTOSANS_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x00, 0x5F, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x02, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x02,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x1C, 0x61, 0xE3,
  0x06, 0x00, 0x60, 0x60, 0x04, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00,
  0x80, 0x60, 0x08, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0xE6, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7E, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00,
  0x60, 0x20, 0x06, 0x03, 0x00, 0x60, 0x10, 0x06, 0x01, 0x00, 0x60, 0x10,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x0C,
  0xE0, 0x63, 0x83, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x18, 0x30, 0x00, 0x20, 0x08,
  0x0C, 0x00, 0x20, 0x08, 0x02, 0x00, 0x10, 0x04, 0x01, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x08, 0x01, 0x00, 0x10, 0x0C, 0x00,
  0x80, 0x08, 0x04, 0x00, 0x40, 0x04, 0x06, 0x00, 0x20, 0x02, 0x02, 0x00,
  0x10, 0x01, 0x02, 0x00, 0x08, 0x00, 0x81, 0x00, 0x04, 0x00, 0x41, 0x00,
  0x03, 0x00, 0x21, 0x87, 0xF1, 0x80, 0x30, 0x86, 0x0C, 0x40, 0x18, 0xC6,
  0x02, 0x20, 0x08, 0x42, 0x01, 0x98, 0x0C, 0x63, 0x00, 0x46, 0x0C, 0x21,
  0x00, 0x21, 0xFC, 0x20, 0x80, 0x18, 0x00, 0x10, 0x40, 0x0C, 0x00, 0x10,
  0x20, 0x02, 0x00, 0x18, 0x10, 0x01, 0x00, 0x08, 0x08, 0x00, 0x80, 0x0C,
  0x04, 0x00, 0x40, 0x04, 0x02, 0x00, 0x20, 0x06, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x04, 0x01,
  0x00, 0x08, 0x06, 0x01, 0x80, 0x06, 0x02, 0x00, 0x80, 0x01, 0x83, 0x00,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x04, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x18, 0xC0,
  0x0C, 0x00, 0x46, 0x00, 0x18, 0x01, 0x10, 0x00, 0x30, 0x0C, 0xC0, 0x00,
  0x60, 0x23, 0x00, 0x00, 0xC1, 0x88, 0x00, 0x01, 0x84, 0x20, 0x00, 0x02,
  0x30, 0x80, 0x00, 0x04, 0x83, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0xA0, 0x20, 0x00, 0x08, 0x40, 0xC0, 0x00, 0xC0, 0x80,
  0xC0, 0x0E, 0x01, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0x81, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0xC0, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x40, 0xC0, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x1C,
  0x04, 0x07, 0x3C, 0x21, 0xE0, 0x1D, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xA0,
  0x00, 0x09, 0x00, 0x00, 0x44, 0x00, 0x04, 0x10, 0x00, 0x40, 0xC0, 0x06,
  0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x13, 0x33, 0x22, 0x66, 0x44, 0xC8, 0xFF, 0xF0, 0x5F, 0x80,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x10, 0x18, 0x00, 0x60, 0x40, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x19, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x09, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00,
  0x60, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x3C, 0x0D, 0x83, 0x31, 0xC6,
  0x60, 0xD8, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x07, 0xFE, 0x00, 0xE0, 0x18, 0x1C,
  0x00, 0x20, 0x80, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x78, 0x03, 0x03, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x63, 0xC0, 0x07, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x04, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x30, 0x04,
  0x00, 0x08, 0x01, 0x00, 0x04, 0x00, 0x40, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x04, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x10, 0x0C,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xE1,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x1F, 0xE0,
  0x0F, 0xC1, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x80, 0x01, 0x87,
  0x00, 0x38, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x01, 0x80, 0x10, 0x7F,
  0xE0, 0x47, 0x00, 0xC3, 0x30, 0x00, 0xCD, 0x00, 0x01, 0x38, 0x00, 0x02,
  0xE0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40,
  0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x60, 0x00,
  0x0C, 0x80, 0x00, 0x23, 0x00, 0x00, 0x84, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x70, 0x0C, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x38, 0x07, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80, 0x00,
  0x42, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30, 0x07, 0x00,
  0x70, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x38, 0x30, 0x00, 0x31, 0x80, 0x00, 0x44, 0x00, 0x01,
  0x90, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x30, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x30, 0x0E, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x21,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x40, 0x00, 0x39, 0x80, 0x01, 0xA3,
  0x00, 0x0C, 0x87, 0x00, 0xE2, 0x07, 0xFE, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFC, 0x39,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x18, 0xC6, 0x21, 0x18, 0xC4, 0x23, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x1F, 0xC0, 0x04, 0xC0, 0x03, 0xCF, 0x80, 0x34, 0x00, 0x70,
  0x04, 0x01, 0xA0, 0x06, 0x00, 0x20, 0x07, 0x00, 0x20, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x08, 0x01, 0x80, 0x30, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x02,
  0x00, 0x60, 0x08, 0x00, 0x10, 0x03, 0x00, 0x40, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x04, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x80, 0x03, 0x00,
  0x30, 0x04, 0x00, 0x18, 0x03, 0x80, 0x20, 0x00, 0xC0, 0x14, 0x01, 0x80,
  0x0A, 0x00, 0xA0, 0x04, 0x00, 0xD0, 0x09, 0x80, 0x10, 0x0C, 0xC0, 0xC4,
  0x00, 0x7B, 0xC3, 0xFC, 0x20, 0x00, 0xF0, 0x07, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x08, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x40, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFE,
  0x02, 0x00, 0x3F, 0x08, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00,
  0xC8, 0x00, 0x06, 0x20, 0x00, 0xF0, 0xFF, 0xFE, 0x02, 0x00, 0x1F, 0x08,
  0x00, 0x07, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0,
  0x00, 0x0C, 0x80, 0x00, 0x62, 0x00, 0x1F, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x60, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x07, 0xE0, 0x08,
  0x00, 0x0E, 0x02, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x06, 0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0xE0, 0x20, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xD0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x38, 0x00, 0x01, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x33, 0xFC, 0x04, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x20, 0x18, 0x00, 0x80, 0xC0, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x21, 0xC0, 0x00, 0x89, 0x80, 0x02, 0x43, 0x00, 0x0A, 0x04, 0x00, 0x30,
  0x18, 0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x08, 0x00, 0x80, 0x20, 0x03,
  0x00, 0x80, 0x06, 0x02, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x00, 0x59,
  0x00, 0x00, 0x01, 0x32, 0x00, 0x00, 0x02, 0x66, 0x00, 0x00, 0x0C, 0xC4,
  0x00, 0x00, 0x11, 0x8C, 0x00, 0x00, 0x63, 0x08, 0x00, 0x00, 0x86, 0x10,
  0x00, 0x01, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x20, 0x00, 0x08, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x40, 0x00, 0x40, 0xC0, 0x80, 0x00, 0x81, 0x81, 0x80,
  0x03, 0x03, 0x01, 0x00, 0x04, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x02, 0x00,
  0x20, 0x18, 0x04, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x10, 0x10, 0x03, 0x00, 0x30, 0x60,
  0x06, 0x00, 0x20, 0x80, 0x0C, 0x00, 0x41, 0x00, 0x18, 0x00, 0xC6, 0x00,
  0x30, 0x00, 0x88, 0x00, 0x60, 0x01, 0xB0, 0x00, 0xC0, 0x01, 0x40, 0x01,
  0x80, 0x02, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x88, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x04, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x41, 0x80, 0x00, 0x61, 0x80, 0x00, 0x31,
  0x80, 0x00, 0x11, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x08, 0x01, 0xF0, 0x80, 0x01,
  0x88, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0xC8,
  0x00, 0x18, 0x80, 0x1F, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x02, 0x00, 0x3C, 0x08, 0x00, 0x1C, 0x20, 0x00, 0x18, 0x80,
  0x00, 0x22, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x01, 0x82, 0x00,
  0x1C, 0x0F, 0xFF, 0xC0, 0x20, 0x06, 0x00, 0x80, 0x08, 0x02, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x20, 0x00, 0x80, 0x80, 0x03, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x88, 0x00,
  0x02, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xC0, 0x60, 0x03, 0x8C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xC7, 0x00, 0x1C, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x13, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x08, 0x18, 0x00, 0x18, 0x03, 0x80, 0x38, 0x00, 0xFF, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10,
  0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x60, 0x06, 0x00, 0x04, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x80, 0x01, 0x00, 0x18, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x24,
  0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x98, 0x00, 0x13,
  0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0xC4, 0x00, 0x18,
  0x60, 0x01, 0x08, 0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x40, 0x80, 0x0C,
  0x10, 0x00, 0x81, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00, 0x20, 0x60, 0x04,
  0x02, 0x00, 0x40, 0x40, 0x08, 0x04, 0x01, 0x80, 0x80, 0x30, 0x08, 0x02,
  0x01, 0x00, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x10, 0x18, 0x02, 0x01,
  0x00, 0x20, 0x30, 0x04, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x00, 0xC0,
  0x80, 0x18, 0x10, 0x00, 0x83, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x08, 0x00, 0x61, 0x00, 0x02, 0x10, 0x00, 0x42, 0x00, 0x04,
  0x60, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x01, 0x90, 0x00, 0x19, 0x00, 0x03,
  0x20, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x20,
  0x00, 0xC0, 0x18, 0x00, 0x40, 0x04, 0x00, 0x40, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x18, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x04, 0x40, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x08, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00,
  0x40, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x02, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x02, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x60, 0x20, 0x00, 0x20, 0x18, 0x00, 0x30, 0x04, 0x00,
  0x10, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x10,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x11, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFC, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x43, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x80, 0x01, 0x80,
  0x80, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x20, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0xFE, 0x03, 0xC0, 0x70, 0x40, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x01, 0xF0, 0x1F, 0xFE, 0x1E, 0x00, 0x46,
  0x00, 0x09, 0x80, 0x01, 0x60, 0x00, 0x28, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x01, 0x50, 0x00, 0x6B, 0x00, 0x19, 0x30,
  0x06, 0x21, 0xFF, 0x04, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x7F,
  0xC0, 0xC6, 0x01, 0xC3, 0x30, 0x01, 0x8D, 0x80, 0x02, 0x3C, 0x00, 0x0C,
  0xE0, 0x00, 0x13, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x2C, 0x00, 0x01, 0xB8, 0x00, 0x04, 0xE0, 0x00, 0x33, 0xC0,
  0x01, 0x8D, 0x80, 0x0C, 0x33, 0x80, 0x60, 0x83, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x70, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x40, 0x7F, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x03, 0xFC, 0x10, 0x60, 0x18, 0x84, 0x00,
  0x64, 0x40, 0x01, 0xA4, 0x00, 0x05, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03,
  0x60, 0x00, 0x29, 0x80, 0x01, 0x46, 0x00, 0x12, 0x1C, 0x03, 0x10, 0x3F,
  0xF0, 0x80, 0x01, 0xFE, 0x00, 0x70, 0x38, 0x0C, 0x00, 0xC1, 0x00, 0x04,
  0x30, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x60, 0x3F, 0xFC, 0x01, 0xFF, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x08,
  0x30, 0x0C, 0x46, 0x00, 0x12, 0x20, 0x00, 0x52, 0x00, 0x03, 0xB0, 0x00,
  0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80,
  0x00, 0x36, 0x00, 0x01, 0x90, 0x00, 0x14, 0xC0, 0x01, 0xA3, 0x00, 0x19,
  0x0E, 0x01, 0x88, 0x1F, 0xF0, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x90, 0x00, 0x18, 0xE0, 0x01, 0x81, 0xFD, 0xF8, 0x01, 0xFC,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x3F, 0xF0, 0xC6, 0x01, 0x8C, 0x80, 0x0C,
  0xD0, 0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xF4, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x02, 0x06, 0xDC, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0x30,
  0x00, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x14, 0x00,
  0xC8, 0x80, 0x34, 0x30, 0x0F, 0x06, 0x03, 0x80, 0x80, 0xC0, 0x10, 0x30,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0xCC, 0x00,
  0x1B, 0x00, 0x02, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x83, 0xFC, 0x03, 0xFC, 0x23, 0x81, 0x83, 0x81,
  0x8D, 0x80, 0x31, 0x80, 0x33, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x00, 0xA0,
  0x00, 0xB8, 0x00, 0x30, 0x00, 0x2C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x83, 0xFF, 0x08, 0x60, 0x18,
  0xC8, 0x00, 0xCD, 0x00, 0x06, 0xE0, 0x00, 0x2E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x01, 0xFF, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x0C, 0x30,
  0x00, 0x11, 0x80, 0x00, 0x64, 0x00, 0x00, 0x90, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00,
  0x41, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x0F, 0xFC, 0x00,
  0xC1, 0xFF, 0x03, 0x1C, 0x07, 0x0C, 0xC0, 0x06, 0x36, 0x00, 0x08, 0xD0,
  0x00, 0x13, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x13, 0xC0, 0x00,
  0xCD, 0x00, 0x02, 0x36, 0x00, 0x10, 0xCE, 0x01, 0x83, 0x0F, 0xFC, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x30, 0x0C, 0x46,
  0x00, 0x32, 0x60, 0x00, 0xD2, 0x00, 0x02, 0xB0, 0x00, 0x0D, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00,
  0x03, 0xB0, 0x00, 0x14, 0xC0, 0x01, 0xA3, 0x00, 0x19, 0x0C, 0x03, 0x88,
  0x3F, 0xF0, 0x40, 0x08, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0xC3, 0xFF, 0x38, 0x0D,
  0x80, 0x34, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x73, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x06,
  0xE0, 0x07, 0x0F, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x74, 0x00, 0x07, 0x60, 0x00, 0xB3, 0x00,
  0x13, 0x18, 0x06, 0x30, 0xFF, 0xC1, 0x80, 0x00, 0x0A, 0x00, 0x00, 0xD0,
  0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10, 0xC0, 0x01,
  0x82, 0x00, 0x08, 0x18, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x20, 0x18,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x40,
  0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x64, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0xC0,
  0x01, 0x80, 0x02, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60,
  0x02, 0x40, 0x04, 0x20, 0x02, 0x60, 0x04, 0x20, 0x06, 0x20, 0x04, 0x30,
  0x04, 0x20, 0x0C, 0x30, 0x04, 0x30, 0x08, 0x10, 0x0C, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x18, 0x18, 0x08, 0x18, 0x18, 0x08, 0x18, 0x08, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x01, 0x40, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x60,
  0x00, 0x11, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80, 0x08,
  0x02, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x04, 0x00, 0x0C,
  0x60, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x60, 0x00, 0x11, 0x00, 0x01, 0x84, 0x00, 0x18, 0x30, 0x00, 0x80,
  0xC0, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x86,
  0x00, 0x04, 0x60, 0x00, 0x36, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10,
  0xC0, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00,
  0x20, 0x18, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x08, 0x0C, 0x00,
  0x40, 0x40, 0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x64, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3C, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x07, 0xC0,
  0x38, 0x00, 0x3F, 0xC0, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xE3, 0x80, 0x00,
  0xF8,
};

const GFXglyph NotoSans_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 35, 11, 4, -35 },
  { 15, 8, 13, 16, 4, -35 },
  { 28, 29, 35, 32, 1, -35 },
  { 155, 20, 40, 28, 3, -37 },
  { 255, 33, 35, 39, 3, -35 },
  { 400, 30, 36, 34, 3, -36 },
  { 535, 1, 13, 8, 4, -35 },
  { 537, 9, 43, 13, 2, -35 },
  { 586, 8, 43, 13, 2, -35 },
  { 629, 21, 20, 27, 3, -37 },
  { 682, 22, 23, 28, 3, -29 },
  { 746, 4, 12, 9, 2, -6 },
  { 752, 12, 1, 16, 2, -14 },
  { 754, 3, 3, 11, 4, -3 },
  { 756, 14, 35, 16, 1, -35 },
  { 818, 22, 36, 28, 3, -36 },
  { 917, 11, 35, 28, 5, -35 },
  { 966, 21, 35, 28, 3, -35 },
  { 1058, 22, 35, 28, 2, -35 },
  { 1155, 26, 35, 28, 1, -35 },
  { 1269, 21, 35, 28, 4, -35 },
  { 1361, 22, 36, 28, 3, -36 },
  { 1460, 22, 35, 28, 3, -35 },
  { 1557, 22, 35, 28, 3, -35 },
  { 1654, 22, 36, 28, 3, -35 },
  { 1753, 3, 26, 11, 4, -26 },
  { 1763, 5, 32, 11, 2, -26 },
  { 1783, 22, 22, 28, 3, -29 },
  { 1844, 22, 11, 28, 3, -23 },
  { 1875, 22, 22, 28, 3, -29 },
  { 1936, 16, 35, 20, 2, -35 },
  { 2006, 37, 40, 43, 3, -35 },
  { 2191, 28, 35, 28, 0, -35 },
  { 2314, 22, 35, 30, 5, -35 },
  { 2411, 26, 35, 30, 3, -35 },
  { 2525, 26, 35, 34, 5, -35 },
  { 2639, 19, 35, 27, 5, -35 },
  { 2723, 19, 35, 24, 5, -35 },
  { 2807, 28, 36, 35, 3, -36 },
  { 2933, 25, 35, 35, 5, -35 },
  { 3043, 8, 35, 14, 3, -35 },
  { 3078, 11, 44, 11, -5, -35 },
  { 3139, 22, 35, 27, 5, -35 },
  { 3236, 19, 35, 25, 5, -35 },
  { 3320, 31, 35, 41, 5, -35 },
  { 3456, 24, 35, 34, 5, -35 },
  { 3561, 31, 36, 37, 3, -36 },
  { 3701, 20, 35, 28, 5, -35 },
  { 3789, 31, 44, 37, 3, -36 },
  { 3960, 22, 35, 28, 5, -35 },
  { 4057, 21, 35, 27, 3, -35 },
  { 4149, 25, 35, 25, 0, -35 },
  { 4259, 25, 35, 35, 5, -35 },
  { 4369, 28, 35, 28, 0, -35 },
  { 4492, 39, 35, 43, 2, -35 },
  { 4663, 25, 35, 25, 0, -35 },
  { 4773, 25, 35, 25, 0, -35 },
  { 4883, 24, 35, 28, 2, -35 },
  { 4988, 10, 43, 15, 4, -35 },
  { 5042, 14, 35, 16, 1, -35 },
  { 5104, 10, 43, 15, 1, -35 },
  { 5158, 24, 21, 28, 2, -35 },
  { 5221, 19, 2, 19, 0, 4 },
  { 5226, 8, 8, 12, 2, -38 },
  { 5234, 19, 26, 25, 2, -26 },
  { 5296, 22, 37, 29, 4, -37 },
  { 5398, 19, 26, 23, 3, -26 },
  { 5460, 21, 37, 29, 3, -37 },
  { 5558, 20, 26, 26, 3, -26 },
  { 5623, 16, 37, 13, 1, -37 },
  { 5697, 21, 38, 29, 3, -26 },
  { 5797, 20, 37, 28, 4, -37 },
  { 5890, 2, 35, 10, 4, -35 },
  { 5899, 8, 47, 10, -2, -35 },
  { 5946, 18, 37, 22, 4, -37 },
  { 6030, 2, 37, 10, 4, -37 },
  { 6040, 34, 26, 42, 4, -26 },
  { 6151, 20, 26, 28, 4, -26 },
  { 6216, 22, 26, 28, 3, -26 },
  { 6288, 22, 37, 29, 4, -26 },
  { 6390, 21, 37, 29, 3, -26 },
  { 6488, 14, 26, 18, 4, -26 },
  { 6534, 18, 26, 22, 2, -26 },
  { 6593, 14, 32, 16, 0, -32 },
  { 6649, 20, 26, 28, 4, -26 },
  { 6714, 21, 26, 21, 0, -26 },
  { 6783, 32, 26, 34, 1, -26 },
  { 6887, 21, 26, 23, 1, -26 },
  { 6956, 21, 38, 21, 0, -26 },
  { 7056, 18, 26, 22, 2, -26 },
  { 7115, 14, 43, 17, 1, -35 },
  { 7191, 2, 49, 26, 12, -37 },
  { 7204, 13, 43, 17, 2, -35 },
  { 7274, 22, 4, 28, 3, -19 },
};

const GFXfont NotoSans_Thin49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin49pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_THIN49PT7B_H_
