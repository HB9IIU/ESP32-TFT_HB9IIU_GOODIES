#ifndef _NOTOSANS_THIN10PT7B_H_
#define _NOTOSANS_THIN10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x4F, 0xCC, 0x65,
  0x5A, 0x40, 0xCA, 0xAB, 0xBD, 0x35, 0x54, 0xC0, 0xF2, 0x46, 0x28, 0x96,
  0x2F, 0x40, 0xC0, 0x5A, 0xA9, 0x40, 0x95, 0x55, 0x80, 0x44, 0xFE, 0x44,
  0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x25, 0x25, 0x20, 0xF9, 0x99, 0x99, 0xF0,
  0x75, 0x54, 0xF1, 0x12, 0x48, 0xF0, 0xF8, 0x42, 0x60, 0x87, 0xE0, 0x10,
  0xA2, 0x92, 0xFC, 0x20, 0x80, 0xF8, 0xE1, 0x11, 0xF0, 0xF8, 0xE9, 0x99,
  0xF0, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x9B, 0x51,
  0xE0, 0x08, 0x0C, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xF1,
  0x12, 0x40, 0x40, 0x7D, 0x06, 0xEE, 0x5C, 0xB7, 0xE0, 0x3C, 0x20, 0xC5,
  0x12, 0x7A, 0x18, 0x40, 0xF4, 0x65, 0xE8, 0xC7, 0xC0, 0x7C, 0x21, 0x08,
  0x41, 0xE0, 0xF4, 0x63, 0x18, 0xC7, 0xC0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C, 0x63, 0xF8, 0xC6,
  0x20, 0xFE, 0x55, 0x55, 0xC0, 0x9D, 0x31, 0x8A, 0x4A, 0x20, 0x88, 0x88,
  0x88, 0xF0, 0x86, 0x1C, 0xF3, 0xAE, 0xD9, 0x40, 0x8C, 0x73, 0x59, 0xCE,
  0x20, 0xFA, 0x18, 0x61, 0x86, 0x17, 0x80, 0xF9, 0x9F, 0x88, 0x80, 0xFA,
  0x18, 0x61, 0x86, 0x16, 0x84, 0x08, 0xF4, 0x65, 0xCA, 0x4A, 0x20, 0xF8,
  0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xC7,
  0xE0, 0x86, 0x24, 0x92, 0x50, 0xC2, 0x00, 0x89, 0x99, 0x55, 0x55, 0x56,
  0x66, 0x22, 0x8A, 0x88, 0x45, 0x2A, 0x20, 0x8A, 0x54, 0x42, 0x10, 0x80,
  0x78, 0x44, 0x42, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5,
  0x55, 0xC0, 0x21, 0x93, 0x10, 0xF0, 0x90, 0x71, 0x79, 0xF0, 0x88, 0xE9,
  0x99, 0x9F, 0xF2, 0x4E, 0x11, 0x79, 0x99, 0x9F, 0xF9, 0xE8, 0xF0, 0x2B,
  0xA4, 0x92, 0xF9, 0x99, 0xF1, 0xF0, 0x88, 0xE9, 0x99, 0x99, 0x3E, 0x05,
  0x55, 0xC0, 0x88, 0x8A, 0xCC, 0xA9, 0xFF, 0xFF, 0x26, 0x4C, 0x99, 0x20,
  0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99,
  0xF1, 0x10, 0xF2, 0x48, 0xF8, 0x61, 0xF0, 0x5D, 0x24, 0x98, 0x99, 0x99,
  0xF0, 0x99, 0x56, 0x40, 0x93, 0x55, 0xB2, 0x24, 0x40, 0xD6, 0x25, 0x90,
  0x99, 0x56, 0x44, 0xC0, 0x72, 0x24, 0xF0, 0x69, 0x2C, 0x92, 0x20, 0xFF,
  0xE0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 8, 1, -7 },
  { 20, 6, 7, 7, 1, -7 },
  { 26, 1, 2, 2, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 2, 9, 3, 0, -7 },
  { 33, 4, 4, 6, 1, -8 },
  { 35, 4, 5, 6, 1, -6 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 3, 1, 3, 0, -3 },
  { 40, 1, 1, 2, 1, -1 },
  { 41, 3, 7, 3, 0, -7 },
  { 44, 4, 7, 6, 1, -7 },
  { 48, 2, 7, 6, 1, -7 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 5, 7, 6, 0, -7 },
  { 59, 6, 7, 6, 0, -7 },
  { 65, 4, 7, 6, 1, -7 },
  { 69, 4, 7, 6, 1, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 1, 5, 2, 1, -5 },
  { 86, 1, 6, 2, 0, -5 },
  { 87, 4, 5, 6, 1, -6 },
  { 90, 4, 3, 6, 1, -5 },
  { 92, 4, 5, 6, 1, -6 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 7, 8, 9, 1, -7 },
  { 106, 6, 7, 6, 0, -7 },
  { 112, 5, 7, 6, 1, -7 },
  { 117, 5, 7, 6, 1, -7 },
  { 122, 5, 7, 7, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 5, 1, -7 },
  { 135, 5, 7, 7, 1, -7 },
  { 140, 5, 7, 7, 1, -7 },
  { 145, 1, 7, 3, 1, -7 },
  { 146, 2, 9, 2, -1, -7 },
  { 149, 5, 7, 6, 1, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 6, 7, 8, 1, -7 },
  { 164, 5, 7, 7, 1, -7 },
  { 169, 6, 7, 8, 1, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 6, 9, 8, 1, -7 },
  { 186, 5, 7, 6, 1, -7 },
  { 191, 4, 7, 5, 1, -7 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 5, 7, 7, 1, -7 },
  { 205, 6, 7, 6, 0, -7 },
  { 211, 8, 7, 9, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 5, 7, 6, 0, -7 },
  { 233, 2, 9, 3, 1, -7 },
  { 236, 3, 7, 3, 0, -7 },
  { 239, 2, 9, 3, 0, -7 },
  { 242, 5, 4, 6, 0, -7 },
  { 245, 4, 1, 4, 0, 1 },
  { 246, 2, 2, 2, 0, -8 },
  { 247, 4, 5, 5, 0, -5 },
  { 250, 4, 8, 6, 1, -8 },
  { 254, 3, 5, 5, 1, -5 },
  { 256, 4, 8, 6, 1, -8 },
  { 260, 4, 5, 5, 1, -5 },
  { 263, 3, 8, 3, 0, -8 },
  { 266, 4, 7, 6, 1, -5 },
  { 270, 4, 8, 6, 1, -8 },
  { 274, 1, 7, 2, 1, -7 },
  { 275, 2, 9, 2, -1, -7 },
  { 278, 4, 8, 5, 1, -8 },
  { 282, 1, 8, 2, 1, -8 },
  { 283, 7, 5, 9, 1, -5 },
  { 288, 4, 5, 6, 1, -5 },
  { 291, 4, 5, 6, 1, -5 },
  { 294, 4, 7, 6, 1, -5 },
  { 298, 4, 7, 6, 1, -5 },
  { 302, 3, 5, 4, 1, -5 },
  { 304, 4, 5, 5, 0, -5 },
  { 307, 3, 7, 3, 0, -7 },
  { 310, 4, 5, 6, 1, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 7, 5, 7, 0, -5 },
  { 321, 4, 5, 5, 0, -5 },
  { 324, 4, 7, 4, 0, -5 },
  { 328, 4, 5, 5, 0, -5 },
  { 331, 3, 9, 3, 0, -7 },
  { 335, 1, 11, 5, 2, -8 },
  { 337, 3, 9, 3, 0, -7 },
  { 341, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_Thin10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin10pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_THIN10PT7B_H_
