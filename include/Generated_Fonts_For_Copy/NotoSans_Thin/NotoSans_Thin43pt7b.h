#ifndef _NOTOSANS_THIN43PT7B_H_
#define _NOTOSANS_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x3C, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x30, 0x08, 0x00,
  0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x20, 0x10,
  0x00, 0x18, 0x04, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x30, 0x00, 0x10, 0x08, 0x03, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x80, 0x00,
  0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x04, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08,
  0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00,
  0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0xFF, 0x83, 0x88, 0x73,
  0x04, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x0C, 0x08, 0x02, 0x04, 0x00, 0x82, 0x00, 0x31, 0x00, 0x06,
  0x80, 0x00, 0xE0, 0x00, 0x2C, 0x00, 0x11, 0x80, 0x08, 0x20, 0x04, 0x08,
  0x02, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x10, 0x04, 0x1A, 0x02, 0x19, 0xFF, 0xF0, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x02, 0x01, 0x04, 0x00,
  0x30, 0x10, 0x10, 0x01, 0x01, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x04, 0x00, 0x80,
  0x20, 0x60, 0x04, 0x01, 0x02, 0x00, 0x20, 0x08, 0x30, 0x01, 0x00, 0x41,
  0x00, 0x08, 0x02, 0x10, 0x78, 0x40, 0x10, 0x8C, 0x62, 0x00, 0x88, 0xC0,
  0x98, 0x08, 0x44, 0x06, 0x40, 0x44, 0x60, 0x11, 0x0C, 0x62, 0x00, 0x87,
  0xC2, 0x10, 0x04, 0x00, 0x30, 0x80, 0x20, 0x01, 0x04, 0x01, 0x80, 0x10,
  0x20, 0x0C, 0x00, 0x81, 0x00, 0x60, 0x08, 0x08, 0x02, 0x00, 0x40, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x40, 0x60,
  0x30, 0x02, 0x02, 0x01, 0x00, 0x08, 0x30, 0x10, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x04, 0x00,
  0x10, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x18, 0x01, 0x00, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x26, 0x00, 0xC0,
  0x13, 0x00, 0x18, 0x04, 0x80, 0x03, 0x01, 0x20, 0x00, 0x60, 0x88, 0x00,
  0x08, 0x22, 0x00, 0x01, 0x10, 0x80, 0x00, 0x28, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x81, 0x00, 0x01, 0x90, 0x60, 0x00, 0xC2, 0x06, 0x00, 0xC0,
  0x40, 0xFF, 0xC0, 0x0C, 0xFF, 0xE0, 0x02, 0x08, 0x30, 0x41, 0x82, 0x08,
  0x10, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x80, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x10, 0x20, 0x83, 0x04,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x08, 0x08, 0x07, 0x82, 0x0F, 0x1C, 0x9C, 0x00, 0xF8,
  0x00, 0x0C, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01, 0x84, 0x00, 0x40, 0x80,
  0x20, 0x30, 0x18, 0x06, 0x04, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x24, 0xB4, 0x96,
  0x92, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01, 0x81, 0xC0, 0x60, 0x0C, 0x18,
  0x00, 0x82, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x81, 0x00,
  0x30, 0x18, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x70, 0x34, 0x31, 0x18,
  0x4C, 0x1C, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x07, 0xF0, 0x0E,
  0x03, 0x0E, 0x00, 0x61, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0x80, 0xC1,
  0x80, 0x06, 0x60, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x68, 0x00, 0x19, 0xC0, 0x06, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x20, 0x80, 0x00,
  0xC1, 0x00, 0x03, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x08, 0x00, 0x60,
  0x10, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x30, 0x01,
  0x00, 0x40, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x18, 0x00, 0x10,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xFF, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xBF, 0xF8,
  0x08, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x31,
  0xC0, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x10, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x1F, 0x81,
  0x0C, 0x0C, 0x26, 0x00, 0x65, 0x80, 0x04, 0xE0, 0x00, 0x58, 0x00, 0x0B,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x08, 0x80, 0x01, 0x18, 0x00, 0x41,
  0x80, 0x18, 0x18, 0x06, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0x80, 0xC0, 0xC0, 0x04, 0x10, 0x00, 0xC4, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00,
  0x10, 0x80, 0x06, 0x18, 0x01, 0x80, 0xC0, 0x40, 0x0E, 0x30, 0x00, 0x38,
  0x00, 0x19, 0xC0, 0x0C, 0x0E, 0x06, 0x00, 0x61, 0x80, 0x06, 0x20, 0x00,
  0x6C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0B, 0x00, 0x01, 0x20, 0x00, 0x42, 0x00, 0x18, 0x30, 0x0E,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xC0, 0x60, 0x10, 0x03, 0x02, 0x00,
  0x18, 0x20, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x03, 0x60, 0x00, 0x62, 0x00, 0x0A, 0x10, 0x01, 0xA0, 0xC0, 0x62,
  0x07, 0xF8, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x33, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x22, 0x26, 0x44, 0x4C, 0x88, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0x01,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x04, 0x30, 0x00, 0xF8, 0x01, 0x08, 0x01, 0xE1, 0xC0, 0x26, 0x00,
  0xC0, 0x10, 0x09, 0x00, 0x60, 0x0C, 0x02, 0x40, 0x30, 0x03, 0x00, 0x90,
  0x08, 0x00, 0xC0, 0x2C, 0x02, 0x00, 0x20, 0x0E, 0x01, 0x80, 0x08, 0x03,
  0x80, 0x40, 0x02, 0x00, 0xA0, 0x10, 0x00, 0x80, 0x28, 0x04, 0x00, 0x20,
  0x0A, 0x01, 0x00, 0x08, 0x02, 0xC0, 0x60, 0x06, 0x00, 0x90, 0x08, 0x01,
  0x80, 0x44, 0x03, 0x00, 0x90, 0x11, 0x00, 0x60, 0x64, 0x08, 0x40, 0x0F,
  0xE0, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x10, 0x04, 0x00, 0x08, 0x02,
  0x00, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x01, 0xFF, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x40, 0x60, 0x00, 0x30, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x0C, 0x03, 0xF0, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x04,
  0xC0, 0x00, 0x8C, 0x00, 0x30, 0xFF, 0xFC, 0x0C, 0x01, 0xF0, 0xC0, 0x01,
  0x8C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x04, 0xC0, 0x00, 0x8C, 0x00, 0x70, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0x00, 0x70, 0x30, 0x00, 0x43, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0xFC, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x04, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x18, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xE0, 0x0F, 0x03, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x08, 0x00, 0x01, 0x06, 0x00, 0x01, 0x03,
  0x80, 0x07, 0x00, 0x7F, 0xFC, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03, 0x3F, 0x80, 0xC0,
  0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00,
  0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCB, 0x00,
  0x0D, 0x18, 0x00, 0xE0, 0x80, 0x0C, 0x04, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x02, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x4C,
  0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xD0, 0x00, 0x00, 0xBD, 0x00, 0x00, 0x0B, 0xC8, 0x00, 0x01, 0x3C,
  0x80, 0x00, 0x13, 0xCC, 0x00, 0x03, 0x3C, 0x40, 0x00, 0x23, 0xC4, 0x00,
  0x02, 0x3C, 0x20, 0x00, 0x43, 0xC2, 0x00, 0x04, 0x3C, 0x30, 0x00, 0xC3,
  0xC1, 0x00, 0x08, 0x3C, 0x10, 0x00, 0x83, 0xC0, 0x80, 0x10, 0x3C, 0x08,
  0x01, 0x03, 0xC0, 0xC0, 0x30, 0x3C, 0x04, 0x02, 0x03, 0xC0, 0x40, 0x60,
  0x3C, 0x02, 0x04, 0x03, 0xC0, 0x20, 0x40, 0x3C, 0x03, 0x0C, 0x03, 0xC0,
  0x10, 0x80, 0x3C, 0x01, 0x98, 0x03, 0xC0, 0x09, 0x00, 0x3C, 0x00, 0x90,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xD0,
  0x00, 0x0F, 0x60, 0x00, 0x3C, 0xC0, 0x00, 0xF1, 0x00, 0x03, 0xC6, 0x00,
  0x0F, 0x0C, 0x00, 0x3C, 0x10, 0x00, 0xF0, 0x60, 0x03, 0xC0, 0xC0, 0x0F,
  0x01, 0x00, 0x3C, 0x02, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x10, 0x0F, 0x00,
  0x20, 0x3C, 0x00, 0xC0, 0xF0, 0x01, 0x03, 0xC0, 0x02, 0x0F, 0x00, 0x0C,
  0x3C, 0x00, 0x10, 0xF0, 0x00, 0x23, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0x3C,
  0x00, 0x02, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x30, 0x1F, 0x0C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x13, 0x00, 0x08, 0xC0,
  0x1C, 0x3F, 0xF8, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0x30, 0x04, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x0C, 0x07, 0xE0, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x4C,
  0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04,
  0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0xE0, 0xFF, 0xF8,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x08, 0x0C, 0x00,
  0x40, 0xC0, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0xC0,
  0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0x03, 0xFE, 0x01, 0xC0, 0x38, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x19, 0x80, 0x06, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x60, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x80, 0x00, 0x21, 0x80, 0x00,
  0x81, 0x80, 0x03, 0x01, 0xC0, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00,
  0x08, 0x18, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x04, 0x00,
  0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0x81,
  0x80, 0x00, 0x81, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x28,
  0x00, 0x08, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00,
  0x22, 0x00, 0x0A, 0x00, 0x04, 0x40, 0x01, 0x60, 0x01, 0x88, 0x00, 0x44,
  0x00, 0x21, 0x80, 0x08, 0x80, 0x04, 0x10, 0x01, 0x10, 0x00, 0x82, 0x00,
  0x21, 0x00, 0x30, 0x40, 0x08, 0x20, 0x04, 0x0C, 0x01, 0x04, 0x00, 0x80,
  0x80, 0x20, 0xC0, 0x30, 0x10, 0x0C, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x20, 0x20, 0x20, 0x10, 0x04, 0x04, 0x02, 0x06, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x18, 0x20, 0x08, 0x10, 0x01, 0x04, 0x01, 0x86, 0x00, 0x21,
  0x80, 0x10, 0x80, 0x04, 0x20, 0x02, 0x10, 0x00, 0xC4, 0x00, 0x42, 0x00,
  0x08, 0x80, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x90, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x02, 0x80, 0x02, 0x40, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x08, 0x80, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x08, 0x08, 0x00,
  0x60, 0x30, 0x01, 0x00, 0x40, 0x08, 0x01, 0x80, 0x60, 0x02, 0x01, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0x48, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x60, 0x18, 0x01, 0x00, 0x20, 0x08, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00,
  0x02, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x88, 0x00, 0x04,
  0x30, 0x00, 0x20, 0x40, 0x00, 0x81, 0x80, 0x04, 0x02, 0x00, 0x10, 0x0C,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x01, 0x02,
  0x00, 0x04, 0x18, 0x00, 0x08, 0x40, 0x00, 0x32, 0x00, 0x00, 0x48, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x00, 0x20, 0x00,
  0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x20, 0xC0, 0x01,
  0x04, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x81, 0x81, 0x81, 0x80, 0x80, 0x07, 0xF8, 0x3C,
  0x0C, 0x20, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xC1, 0x18, 0x01, 0x60,
  0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0x40, 0x05, 0x60, 0x19, 0x1F, 0xE1, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x0F, 0xE0, 0x46, 0x03, 0x09,
  0x00, 0x31, 0x40, 0x03, 0x38, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x60,
  0x00, 0x6C, 0x00, 0x09, 0xC0, 0x03, 0x2C, 0x00, 0xC4, 0xC0, 0x30, 0x8F,
  0xF8, 0x00, 0x01, 0xFE, 0x06, 0x01, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F,
  0x84, 0x30, 0x19, 0x10, 0x03, 0x48, 0x00, 0x54, 0x00, 0x0D, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x52, 0x00, 0x34, 0x60, 0x19,
  0x0F, 0xF8, 0x40, 0x03, 0xF8, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04,
  0x60, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x60, 0x7F, 0xE0, 0x00, 0xFE, 0x03, 0x08, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x03, 0xFF, 0x80, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x43,
  0x01, 0x91, 0x00, 0x34, 0x80, 0x07, 0x40, 0x00, 0xD0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x05, 0x30, 0x03, 0x46, 0x01, 0x90, 0xFF,
  0x84, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x28, 0x00, 0x11, 0xC0, 0x18, 0x1F, 0xF8, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x21, 0xFE, 0x11,
  0x81, 0xCB, 0x00, 0x35, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x5D,
  0x00, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x02,
  0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0xF8, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40,
  0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9A, 0x00,
  0xB1, 0x00, 0xA1, 0x80, 0xC0, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x30,
  0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x87, 0xE0, 0x1F, 0x84, 0xC0, 0xC3, 0x03, 0x2C, 0x03,
  0x30, 0x0D, 0xC0, 0x0A, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x83, 0xF8, 0x46, 0x07, 0x24, 0x00, 0xD4, 0x00, 0x2C,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x40, 0x04, 0x10,
  0x00, 0x44, 0x00, 0x0C, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x68, 0x00, 0x09, 0x00,
  0x03, 0x10, 0x00, 0x43, 0x00, 0x10, 0x30, 0x0C, 0x01, 0xFF, 0x00, 0x83,
  0xF8, 0x11, 0x80, 0xC2, 0x40, 0x0C, 0x50, 0x00, 0xCA, 0x00, 0x09, 0x80,
  0x00, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00,
  0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x02, 0x50, 0x00, 0xCB, 0x00,
  0x31, 0x30, 0x0C, 0x21, 0xFE, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x20, 0xC0, 0xC4, 0x60,
  0x06, 0x88, 0x00, 0x52, 0x00, 0x06, 0x40, 0x00, 0xD0, 0x00, 0x1A, 0x00,
  0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00,
  0x0C, 0x80, 0x01, 0x90, 0x00, 0x51, 0x00, 0x1A, 0x18, 0x06, 0x41, 0xFF,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x87, 0xF3, 0x02, 0xC0, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x38,
  0x06, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0xC0, 0x0C, 0x7F, 0xF0, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x7F, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x07, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xB8, 0x00, 0x54,
  0x00, 0x49, 0x80, 0xC4, 0x7F, 0xC2, 0x80, 0x00, 0x70, 0x00, 0x14, 0x00,
  0x0D, 0x00, 0x02, 0x20, 0x00, 0x88, 0x00, 0x43, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x02, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x10, 0x04, 0x04, 0x01,
  0x02, 0x00, 0x60, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x02, 0xC0, 0x06, 0x00, 0x24, 0x00, 0x70, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x60, 0x09, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x10, 0x80, 0xC3, 0x01, 0x0C, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x80, 0x84, 0x02, 0x10, 0x08,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x0C, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x22,
  0x00, 0x10, 0x40, 0x0C, 0x08, 0x06, 0x03, 0x01, 0x00, 0x40, 0x80, 0x08,
  0x60, 0x03, 0x10, 0x00, 0x48, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x4C, 0x00, 0x21, 0x00, 0x18, 0x20, 0x04, 0x0C, 0x02, 0x01, 0x01,
  0x80, 0x20, 0x40, 0x0C, 0x20, 0x01, 0x98, 0x00, 0x2C, 0x00, 0x04, 0x80,
  0x00, 0x70, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x43, 0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x02, 0x00, 0x80, 0x80, 0x60,
  0x20, 0x10, 0x04, 0x04, 0x01, 0x02, 0x00, 0x60, 0x80, 0x08, 0x60, 0x02,
  0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x30, 0x1C, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x0E, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x07, 0x80, 0x70, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x03, 0x81, 0x80, 0x00, 0x1F, 0x80, 0x16, 0x0E,
  0x01, 0x80, 0x3C, 0x60, 0x00, 0x38,
};

const GFXglyph NotoSans_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 31, 10, 4, -31 },
  { 9, 8, 11, 14, 3, -31 },
  { 20, 26, 31, 28, 1, -31 },
  { 121, 17, 36, 25, 3, -33 },
  { 198, 29, 31, 34, 3, -31 },
  { 311, 26, 31, 30, 3, -31 },
  { 412, 1, 11, 7, 3, -31 },
  { 414, 7, 38, 11, 2, -31 },
  { 448, 7, 38, 11, 2, -31 },
  { 482, 18, 18, 24, 3, -33 },
  { 523, 20, 20, 25, 2, -25 },
  { 573, 3, 11, 8, 2, -5 },
  { 578, 10, 1, 14, 2, -12 },
  { 580, 2, 2, 9, 4, -2 },
  { 581, 12, 31, 14, 1, -31 },
  { 628, 19, 31, 25, 3, -31 },
  { 702, 10, 31, 25, 4, -31 },
  { 741, 18, 31, 25, 3, -31 },
  { 811, 19, 31, 25, 2, -31 },
  { 885, 23, 31, 25, 1, -31 },
  { 975, 19, 31, 25, 3, -31 },
  { 1049, 19, 31, 25, 3, -31 },
  { 1123, 20, 31, 25, 2, -31 },
  { 1201, 19, 31, 25, 3, -31 },
  { 1275, 20, 32, 25, 2, -31 },
  { 1355, 2, 23, 9, 4, -23 },
  { 1361, 4, 29, 9, 2, -23 },
  { 1376, 20, 19, 25, 2, -25 },
  { 1424, 20, 10, 25, 2, -20 },
  { 1449, 20, 19, 25, 2, -25 },
  { 1497, 14, 31, 18, 2, -31 },
  { 1552, 34, 34, 38, 2, -30 },
  { 1697, 25, 31, 25, 0, -31 },
  { 1794, 20, 31, 26, 4, -31 },
  { 1872, 22, 31, 26, 3, -31 },
  { 1958, 23, 31, 30, 4, -31 },
  { 2048, 17, 31, 24, 4, -31 },
  { 2114, 17, 31, 21, 4, -31 },
  { 2180, 24, 31, 31, 3, -31 },
  { 2273, 22, 31, 30, 4, -31 },
  { 2359, 7, 31, 12, 3, -31 },
  { 2387, 10, 38, 10, -4, -31 },
  { 2435, 20, 31, 24, 4, -31 },
  { 2513, 17, 31, 22, 4, -31 },
  { 2579, 28, 31, 36, 4, -31 },
  { 2688, 22, 31, 30, 4, -31 },
  { 2774, 27, 31, 32, 3, -31 },
  { 2879, 18, 31, 25, 4, -31 },
  { 2949, 27, 38, 32, 3, -31 },
  { 3078, 20, 31, 25, 4, -31 },
  { 3156, 19, 31, 23, 2, -31 },
  { 3230, 22, 31, 22, 0, -31 },
  { 3316, 23, 31, 31, 4, -31 },
  { 3406, 24, 31, 24, 0, -31 },
  { 3499, 35, 31, 37, 1, -31 },
  { 3635, 22, 31, 22, 0, -31 },
  { 3721, 22, 31, 22, 0, -31 },
  { 3807, 21, 31, 25, 2, -31 },
  { 3889, 8, 38, 13, 4, -31 },
  { 3927, 12, 31, 14, 1, -31 },
  { 3974, 9, 38, 13, 1, -31 },
  { 4017, 21, 19, 25, 2, -31 },
  { 4067, 17, 1, 17, 0, 4 },
  { 4070, 7, 7, 11, 2, -33 },
  { 4077, 16, 23, 22, 2, -23 },
  { 4123, 19, 33, 25, 4, -33 },
  { 4202, 16, 23, 20, 3, -23 },
  { 4248, 18, 33, 25, 3, -33 },
  { 4323, 18, 23, 23, 3, -23 },
  { 4375, 15, 33, 12, 0, -33 },
  { 4437, 18, 33, 25, 3, -23 },
  { 4512, 17, 33, 25, 4, -33 },
  { 4583, 3, 31, 9, 3, -31 },
  { 4595, 8, 41, 9, -2, -31 },
  { 4636, 16, 33, 20, 4, -33 },
  { 4702, 1, 33, 9, 4, -33 },
  { 4707, 29, 23, 37, 4, -23 },
  { 4791, 17, 23, 25, 4, -23 },
  { 4840, 19, 23, 25, 3, -23 },
  { 4895, 19, 33, 25, 4, -23 },
  { 4974, 19, 33, 25, 2, -23 },
  { 5053, 11, 23, 16, 4, -23 },
  { 5085, 16, 23, 20, 2, -23 },
  { 5131, 13, 28, 14, 0, -28 },
  { 5177, 17, 23, 25, 4, -23 },
  { 5226, 18, 23, 18, 0, -23 },
  { 5278, 28, 23, 29, 1, -23 },
  { 5359, 18, 23, 21, 1, -23 },
  { 5411, 18, 33, 18, 0, -23 },
  { 5486, 16, 23, 20, 2, -23 },
  { 5532, 12, 38, 14, 1, -31 },
  { 5589, 1, 44, 23, 11, -33 },
  { 5595, 11, 38, 14, 2, -31 },
  { 5648, 20, 4, 25, 2, -17 },
};

const GFXfont NotoSans_Thin43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin43pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_THIN43PT7B_H_
