#ifndef _NOTOSANS_THIN24PT7B_H_
#define _NOTOSANS_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x80, 0x99, 0x99, 0x99, 0x04, 0x20, 0x10, 0x80, 0x42,
  0x02, 0x08, 0x08, 0x21, 0xFF, 0xF0, 0x84, 0x02, 0x10, 0x08, 0x40, 0x41,
  0x01, 0x04, 0x3F, 0xFE, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x21,
  0x00, 0x08, 0x1F, 0x92, 0x31, 0x08, 0x84, 0x42, 0x21, 0x10, 0x68, 0x0E,
  0x02, 0xC1, 0x10, 0x88, 0x44, 0x22, 0x11, 0x89, 0x3F, 0x02, 0x00, 0x3C,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x22, 0x04, 0x11, 0x02,
  0x09, 0x31, 0x04, 0xA6, 0x42, 0xA1, 0x16, 0x90, 0x44, 0x48, 0x20, 0x44,
  0x10, 0x22, 0x08, 0x21, 0x04, 0x10, 0x84, 0x10, 0x22, 0x18, 0x1E, 0x00,
  0x1F, 0x00, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x84, 0x01, 0x20,
  0x03, 0x00, 0x34, 0x01, 0x08, 0x18, 0x10, 0xA0, 0x22, 0x80, 0x52, 0x00,
  0xC8, 0x03, 0x20, 0x12, 0x7F, 0x84, 0xFC, 0x12, 0x24, 0x48, 0x88, 0x88,
  0x88, 0x88, 0x84, 0x44, 0x22, 0x10, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x22, 0x44, 0x80, 0x04, 0x00, 0x80, 0x10, 0x62, 0x33, 0xF8,
  0x08, 0x02, 0x80, 0x88, 0x30, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x56, 0xA0,
  0xFC, 0x80, 0x02, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x80, 0x1F, 0x84, 0x09, 0x01, 0x20, 0x14, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x11, 0x02, 0x1F, 0x80, 0x0C, 0x56, 0x61, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x3F, 0x08, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x3F, 0x98, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x18, 0x1F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0xFF, 0x80, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x84, 0x08, 0x80, 0x88, 0x08,
  0x7F, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFC, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0xFF, 0x00, 0x1F, 0xC8, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0xE2, 0xC6, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x02, 0x3F, 0x00, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x00, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x60, 0x26,
  0x10, 0x78, 0x32, 0x10, 0x68, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x7F, 0x00, 0x3F, 0x88, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0A,
  0x01, 0x40, 0x66, 0x34, 0x38, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x7E, 0x00, 0xC0, 0x08, 0x50, 0x00, 0x05, 0x6A, 0x00, 0x20, 0x18, 0x1C,
  0x0C, 0x02, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x30, 0x38, 0x18, 0x0C, 0x02, 0x00, 0x00, 0xFE,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x01, 0x80, 0x60, 0x40, 0x02, 0x10,
  0x00, 0x24, 0x00, 0x04, 0x81, 0xF0, 0x50, 0xC2, 0x0C, 0x10, 0x41, 0x84,
  0x08, 0x30, 0x81, 0x06, 0x10, 0x20, 0xC2, 0x04, 0x18, 0x41, 0x85, 0x06,
  0x69, 0x10, 0x30, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x10, 0x20, 0x40, 0x83, 0xFF, 0x08, 0x04, 0x20,
  0x11, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x04, 0xFF, 0x90, 0x0A, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x17, 0xEC, 0x83, 0xD0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0xFF, 0x80, 0x0F, 0xF3, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xF0, 0xFF, 0x84,
  0x02, 0x20, 0x09, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x18,
  0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFE,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xF9,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x81,
  0xF4, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x26, 0x01,
  0x0F, 0xF8, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x1F, 0x00, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88, 0x21, 0x08, 0x22,
  0x04, 0x80, 0xA8, 0x18, 0x82, 0x08, 0x41, 0x08, 0x11, 0x01, 0x20, 0x14,
  0x02, 0x80, 0x20, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x05, 0x90,
  0x09, 0x90, 0x09, 0x88, 0x11, 0x88, 0x11, 0x84, 0x11, 0x84, 0x21, 0x84,
  0x21, 0x82, 0x41, 0x82, 0x41, 0x81, 0x81, 0x81, 0x81, 0x80, 0x81, 0x80,
  0x1C, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x84, 0x18, 0x41, 0x82,
  0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x01, 0x80,
  0x10, 0x1F, 0xE0, 0x40, 0x21, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28,
  0x00, 0x50, 0x00, 0x90, 0x02, 0x10, 0x08, 0x1F, 0xE0, 0xFF, 0x20, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x81, 0xBF, 0x88, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x40, 0x21, 0x00,
  0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0x90, 0x02, 0x10,
  0x08, 0x1F, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF,
  0x10, 0x1A, 0x01, 0x40, 0x28, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x83, 0x1F,
  0xC2, 0x08, 0x40, 0x88, 0x09, 0x01, 0x20, 0x14, 0x02, 0x80, 0x20, 0x3F,
  0xC8, 0x01, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0xFF, 0x80, 0xFF,
  0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05,
  0x00, 0x44, 0x04, 0x1F, 0xC0, 0x80, 0x0E, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x08, 0x10, 0x40, 0x41, 0x00, 0x84,
  0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x50, 0x24, 0x0A, 0x04, 0x82,
  0x40, 0x90, 0x44, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x41, 0x10, 0x48,
  0x24, 0x09, 0x04, 0x81, 0x40, 0x90, 0x28, 0x0A, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x40, 0x14, 0x02, 0x20, 0x41, 0x04, 0x10, 0x80,
  0x90, 0x05, 0x00, 0x60, 0x06, 0x00, 0x50, 0x09, 0x01, 0x08, 0x10, 0x42,
  0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04,
  0x20, 0x41, 0x08, 0x10, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x7F, 0xF0, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80,
  0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x81, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x20,
  0x44, 0x04, 0x40, 0x28, 0x03, 0xFF, 0x80, 0x84, 0x30, 0x3E, 0x20, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x7E, 0xC1, 0x80, 0xC0, 0x60, 0x30, 0x37, 0xE8,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x3E, 0x28, 0x26, 0x02, 0x80,
  0x50, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0xC0, 0x97,
  0xE0, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x3E, 0x48, 0x2A, 0x03, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x50, 0x0A, 0x03, 0x20, 0x63, 0xE4, 0x1F, 0x04, 0x11, 0x01, 0x20,
  0x28, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0xFC, 0x0F, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x24, 0x1D, 0x01, 0xA0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0x90, 0x31,
  0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x48, 0x10, 0xFC, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x27, 0x8A, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x8F, 0xFF, 0x80,
  0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0E, 0x05, 0x04, 0x84, 0x44, 0x24,
  0x16, 0x0C, 0x84, 0x22, 0x09, 0x04, 0x81, 0x40, 0x40, 0xFF, 0xFF, 0xC0,
  0x9E, 0x3E, 0xE1, 0x41, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x9F, 0x28, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x1F, 0x84, 0x09, 0x00, 0xA0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x00, 0x90, 0x21,
  0xF8, 0x8F, 0x14, 0x13, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0B, 0x01, 0x60, 0x4B, 0xF1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x00, 0x1F, 0x24, 0x15, 0x01, 0xA0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0xA0, 0x33, 0xFA, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x9F, 0xC3, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x3F, 0xA0, 0x20, 0x10, 0x08,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0, 0x20, 0x40,
  0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0F,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0D, 0x05, 0x3E, 0x40, 0x80, 0x60, 0x14, 0x05, 0x02, 0x40, 0x88,
  0x22, 0x10, 0x44, 0x12, 0x04, 0x80, 0xA0, 0x30, 0x04, 0x00, 0x80, 0x81,
  0x40, 0x81, 0x41, 0x41, 0x41, 0x42, 0x41, 0x42, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x24, 0x14, 0x24, 0x14, 0x14, 0x14, 0x14, 0x08, 0x08, 0x08, 0x08,
  0x80, 0x90, 0x24, 0x10, 0x88, 0x12, 0x05, 0x00, 0x80, 0x50, 0x12, 0x08,
  0x84, 0x11, 0x02, 0x80, 0x40, 0x80, 0x60, 0x14, 0x05, 0x02, 0x40, 0x88,
  0x42, 0x10, 0x44, 0x12, 0x04, 0x80, 0xA0, 0x30, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x0E, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x1C, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x0C, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0C,
  0xFF, 0xFF, 0xFF, 0xC0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0xC4,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0xC0, 0x38, 0x18, 0xC4, 0x07, 0x00,
};

const GFXglyph NotoSans_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 8, 2, -17 },
  { 7, 14, 17, 16, 1, -17 },
  { 37, 9, 19, 14, 2, -18 },
  { 59, 17, 17, 19, 1, -17 },
  { 96, 14, 17, 17, 2, -17 },
  { 126, 1, 6, 4, 2, -17 },
  { 127, 4, 21, 6, 1, -17 },
  { 138, 4, 21, 6, 1, -17 },
  { 149, 11, 9, 13, 1, -18 },
  { 162, 11, 11, 14, 1, -14 },
  { 178, 2, 6, 4, 1, -3 },
  { 180, 6, 1, 8, 1, -7 },
  { 181, 1, 1, 5, 2, -1 },
  { 182, 7, 17, 8, 0, -17 },
  { 197, 11, 17, 14, 1, -17 },
  { 221, 6, 17, 14, 2, -17 },
  { 234, 11, 17, 14, 1, -17 },
  { 258, 11, 17, 14, 1, -17 },
  { 282, 12, 17, 14, 1, -17 },
  { 308, 10, 17, 14, 2, -17 },
  { 330, 10, 17, 14, 2, -17 },
  { 352, 11, 17, 14, 1, -17 },
  { 376, 10, 17, 14, 2, -17 },
  { 398, 11, 17, 14, 1, -17 },
  { 422, 1, 13, 5, 2, -13 },
  { 424, 2, 16, 5, 1, -13 },
  { 428, 11, 11, 14, 1, -14 },
  { 444, 11, 5, 14, 1, -11 },
  { 451, 11, 11, 14, 1, -14 },
  { 467, 8, 17, 10, 1, -17 },
  { 484, 19, 19, 21, 1, -17 },
  { 530, 14, 17, 14, 0, -17 },
  { 560, 11, 17, 15, 2, -17 },
  { 584, 12, 17, 15, 2, -17 },
  { 610, 13, 17, 17, 2, -17 },
  { 638, 10, 17, 13, 2, -17 },
  { 660, 10, 17, 12, 2, -17 },
  { 682, 13, 17, 17, 2, -17 },
  { 710, 12, 17, 17, 2, -17 },
  { 736, 4, 17, 7, 1, -17 },
  { 745, 5, 21, 6, -2, -17 },
  { 759, 11, 17, 13, 2, -17 },
  { 783, 10, 17, 12, 2, -17 },
  { 805, 16, 17, 20, 2, -17 },
  { 839, 12, 17, 17, 2, -17 },
  { 865, 15, 17, 18, 2, -17 },
  { 897, 10, 17, 14, 2, -17 },
  { 919, 15, 21, 18, 2, -17 },
  { 959, 11, 17, 14, 2, -17 },
  { 983, 11, 17, 13, 1, -17 },
  { 1007, 12, 17, 12, 0, -17 },
  { 1033, 13, 17, 17, 2, -17 },
  { 1061, 14, 17, 14, 0, -17 },
  { 1091, 19, 17, 21, 1, -17 },
  { 1132, 12, 17, 12, 0, -17 },
  { 1158, 12, 17, 12, 0, -17 },
  { 1184, 12, 17, 14, 1, -17 },
  { 1210, 5, 21, 8, 2, -17 },
  { 1224, 7, 17, 8, 0, -17 },
  { 1239, 4, 21, 8, 1, -17 },
  { 1250, 12, 10, 14, 1, -17 },
  { 1265, 9, 1, 9, 0, 2 },
  { 1267, 4, 3, 6, 1, -18 },
  { 1269, 9, 13, 12, 1, -13 },
  { 1284, 11, 18, 14, 2, -18 },
  { 1309, 10, 13, 11, 1, -13 },
  { 1326, 11, 18, 14, 1, -18 },
  { 1351, 11, 13, 13, 1, -13 },
  { 1369, 8, 18, 7, 0, -18 },
  { 1387, 11, 19, 14, 1, -13 },
  { 1414, 10, 18, 14, 2, -18 },
  { 1437, 1, 17, 5, 2, -17 },
  { 1440, 4, 23, 5, -1, -17 },
  { 1452, 9, 18, 11, 2, -18 },
  { 1473, 1, 18, 5, 2, -18 },
  { 1476, 16, 13, 20, 2, -13 },
  { 1502, 10, 13, 14, 2, -13 },
  { 1519, 11, 13, 14, 1, -13 },
  { 1537, 11, 19, 14, 2, -13 },
  { 1564, 11, 19, 14, 1, -13 },
  { 1591, 7, 13, 9, 2, -13 },
  { 1603, 9, 13, 11, 1, -13 },
  { 1618, 7, 16, 8, 0, -16 },
  { 1632, 10, 13, 14, 2, -13 },
  { 1649, 10, 13, 10, 0, -13 },
  { 1666, 16, 13, 16, 0, -13 },
  { 1692, 10, 13, 12, 1, -13 },
  { 1709, 10, 19, 10, 0, -13 },
  { 1733, 9, 13, 11, 1, -13 },
  { 1748, 6, 21, 8, 1, -17 },
  { 1764, 1, 24, 13, 6, -18 },
  { 1767, 6, 21, 8, 1, -17 },
  { 1783, 11, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Thin24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin24pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_THIN24PT7B_H_
