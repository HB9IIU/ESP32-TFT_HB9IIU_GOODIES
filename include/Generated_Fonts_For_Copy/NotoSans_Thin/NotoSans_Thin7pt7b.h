#ifndef _NOTOSANS_THIN7PT7B_H_
#define _NOTOSANS_THIN7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0x5E, 0x60, 0xF9, 0x3E, 0xF5, 0x3E, 0x55, 0x80,
  0x73, 0x1B, 0x2F, 0x80, 0xC0, 0x6A, 0xB0, 0x95, 0x60, 0xCD, 0x80, 0x4F,
  0x40, 0xC0, 0xC0, 0x00, 0x56, 0x80, 0xF9, 0x99, 0xF0, 0xF8, 0xE4, 0xAE,
  0xE5, 0x9E, 0x26, 0x6F, 0x20, 0xD1, 0x9E, 0x68, 0xF9, 0x70, 0xF2, 0x22,
  0x40, 0xF9, 0x69, 0xF0, 0xE9, 0xF1, 0x60, 0x80, 0x98, 0x3C, 0x30, 0xF0,
  0xC3, 0xC0, 0xE5, 0x20, 0x7A, 0xDC, 0xF5, 0xA9, 0xC0, 0x46, 0x69, 0x90,
  0xF7, 0x5E, 0x78, 0x88, 0x70, 0xF6, 0xDE, 0xEE, 0xC0, 0xEE, 0x80, 0x78,
  0x89, 0x70, 0xB7, 0xDA, 0xEA, 0xC0, 0x55, 0x70, 0xBA, 0x6A, 0xAA, 0xC0,
  0x99, 0xBB, 0xD0, 0xB7, 0xDA, 0x7C, 0x63, 0x17, 0x80, 0xF7, 0x48, 0x7C,
  0x63, 0x16, 0x88, 0xF7, 0x6A, 0xF1, 0x9E, 0xF4, 0x44, 0x40, 0xB6, 0xDE,
  0x99, 0x66, 0x40, 0xA6, 0x5B, 0x56, 0x48, 0x96, 0x46, 0x90, 0x9A, 0x44,
  0x40, 0xF2, 0x44, 0xF0, 0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x46, 0x90, 0xE0,
  0x80, 0xE7, 0xF0, 0x9A, 0xDE, 0x72, 0x70, 0x2E, 0xDE, 0x77, 0x70, 0xFA,
  0x80, 0x76, 0xF2, 0xC0, 0xBF, 0xC0, 0x78, 0x7E, 0xBA, 0xC0, 0xF8, 0xFB,
  0xBB, 0xFF, 0x69, 0x9F, 0xD6, 0xF9, 0x00, 0x76, 0xF2, 0x40, 0xEA, 0xF1,
  0xF0, 0xBA, 0xC0, 0xFF, 0xB6, 0xA0, 0xAD, 0x74, 0xA0, 0xA9, 0x50, 0xB6,
  0xA5, 0x00, 0xE5, 0x70, 0x56, 0x50, 0xFE, 0xD5, 0x70, 0xF0,
};

const GFXglyph NotoSans_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 4, 5, 5, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 6, 0, -5 },
  { 12, 5, 5, 5, 0, -5 },
  { 16, 1, 2, 1, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 4, 0, -5 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 2, 5, 2, 0, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 1, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 1, 4, 2, 0, -4 },
  { 56, 1, 5, 2, 0, -4 },
  { 57, 4, 3, 4, 0, -4 },
  { 59, 4, 1, 4, 0, -3 },
  { 60, 4, 3, 4, 0, -4 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 6, 6, 6, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 5, 1, -5 },
  { 79, 2, 5, 4, 1, -5 },
  { 81, 2, 5, 3, 1, -5 },
  { 83, 4, 5, 5, 0, -5 },
  { 86, 3, 5, 5, 1, -5 },
  { 88, 2, 5, 2, 0, -5 },
  { 90, 2, 6, 2, -1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 2, 5, 4, 1, -5 },
  { 96, 4, 5, 6, 1, -5 },
  { 99, 3, 5, 5, 1, -5 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 3, 5, 4, 1, -5 },
  { 107, 5, 6, 5, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 3, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 5, 1, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 6, 5, 6, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 1, 6, 2, 1, -5 },
  { 137, 2, 5, 2, 0, -5 },
  { 139, 2, 6, 2, 0, -5 },
  { 141, 4, 3, 4, 0, -5 },
  { 143, 3, 1, 3, 0, 0 },
  { 144, 1, 1, 2, 0, -5 },
  { 145, 3, 4, 4, 0, -4 },
  { 147, 3, 5, 4, 1, -5 },
  { 149, 3, 4, 3, 0, -4 },
  { 151, 3, 5, 4, 0, -5 },
  { 153, 3, 4, 4, 0, -4 },
  { 155, 2, 5, 2, 0, -5 },
  { 157, 3, 6, 4, 0, -4 },
  { 160, 2, 5, 4, 1, -5 },
  { 162, 1, 5, 1, 0, -5 },
  { 163, 1, 7, 1, 0, -5 },
  { 164, 2, 5, 3, 1, -5 },
  { 166, 1, 5, 1, 0, -5 },
  { 167, 4, 4, 6, 1, -4 },
  { 169, 2, 4, 4, 1, -4 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 3, 6, 4, 1, -4 },
  { 175, 3, 6, 4, 0, -4 },
  { 178, 2, 4, 3, 1, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 2, 5, 2, 0, -5 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 5, 4, 5, 0, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 3, 6, 3, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 2, 6, 2, 0, -5 },
  { 198, 1, 7, 4, 1, -5 },
  { 199, 2, 6, 2, 0, -5 },
  { 201, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Thin7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin7pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_THIN7PT7B_H_
