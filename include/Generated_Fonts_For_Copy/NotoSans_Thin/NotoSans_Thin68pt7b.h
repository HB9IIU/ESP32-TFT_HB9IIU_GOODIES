#ifndef _NOTOSANS_THIN68PT7B_H_
#define _NOTOSANS_THIN68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0x00, 0x00, 0x00, 0xBF, 0xE8, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0x86, 0x0F, 0xC0, 0xE0, 0x60, 0x18, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01,
  0xC8, 0x00, 0x60, 0x38, 0x70, 0x06, 0x0F, 0x07, 0xFE, 0x6F, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x00, 0x10,
  0x18, 0x0F, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0xFF, 0x81, 0x00, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x00, 0x0C, 0x18, 0x30, 0x06, 0x18, 0x00, 0x30, 0x61,
  0xC0, 0x0C, 0x60, 0x01, 0x83, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x10,
  0x00, 0x63, 0x80, 0x30, 0x60, 0xC0, 0x01, 0x87, 0x01, 0x83, 0x03, 0x00,
  0x06, 0x0F, 0xBC, 0x0C, 0x0C, 0x00, 0x08, 0x0F, 0xE0, 0x60, 0x20, 0x00,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x40, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x61, 0x80, 0x01, 0x80, 0x00,
  0x31, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x00,
  0x60, 0x06, 0x30, 0x00, 0x00, 0x18, 0x06, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0x83, 0x06, 0x00, 0x00, 0x00, 0x61, 0x83, 0x00,
  0x00, 0x00, 0x19, 0x81, 0x80, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x01, 0xD8,
  0x06, 0x00, 0x00, 0x01, 0xC6, 0x01, 0x80, 0x00, 0x01, 0xC1, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x07, 0x80, 0x18, 0x07, 0xC0, 0x1F,
  0x00, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x80, 0x0F, 0xF8, 0x04, 0x03, 0xF1, 0xF0, 0x20,
  0x7C, 0x00, 0xF1, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x1C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0x80, 0xFF, 0xFF, 0x5F, 0xF4, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xB0,
  0x0E, 0x60, 0x70, 0xC1, 0xC1, 0x86, 0x03, 0x38, 0x06, 0xE0, 0x0F, 0x00,
  0x1A, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x03, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x38, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x03, 0xF8, 0x00, 0xC0, 0x7F, 0xFC, 0x03, 0x07, 0x80, 0x3C, 0x0C,
  0x70, 0x00, 0x18, 0x23, 0x80, 0x00, 0x30, 0x98, 0x00, 0x00, 0x62, 0xC0,
  0x00, 0x00, 0xCB, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0,
  0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x00, 0x78,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x00,
  0x6C, 0x60, 0x00, 0x07, 0x30, 0xC0, 0x00, 0x38, 0xC1, 0xC0, 0x03, 0xC3,
  0x03, 0xF9, 0xFC, 0x0C, 0x03, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5F,
  0xF4, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x61,
  0x86, 0x18, 0xE3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFE, 0xFE, 0x0E, 0x00, 0x1E, 0x20,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x63, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x06, 0x30, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x66,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x02, 0x60, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x36, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x20, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x02, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x06, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x06, 0xC0, 0x03, 0x00, 0x00, 0xD0, 0x00, 0xCC, 0x00, 0x18, 0x00,
  0x09, 0x00, 0x0C, 0xC0, 0x01, 0xC0, 0x01, 0x98, 0x01, 0x84, 0x00, 0x0E,
  0x00, 0x31, 0xC0, 0x30, 0x60, 0x00, 0x78, 0x0E, 0x0E, 0x0F, 0x06, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x3F, 0x80, 0x7F,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x7F, 0x01, 0x80, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0xF8, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x80, 0x78, 0xFF, 0xE0, 0x3F, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x30, 0xDC,
  0x00, 0x00, 0x63, 0x18, 0x00, 0x00, 0xCC, 0x18, 0x00, 0x01, 0xB0, 0x38,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x00,
  0x00, 0x37, 0xB0, 0x00, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0xDE, 0x60, 0x00, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x06, 0x78,
  0xC0, 0x00, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00, 0x00, 0x31, 0xE3, 0x00,
  0x00, 0x00, 0x06, 0x3C, 0x30, 0x00, 0x00, 0x01, 0x87, 0x86, 0x00, 0x00,
  0x00, 0x30, 0xF0, 0x60, 0x00, 0x00, 0x0C, 0x1E, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0xC1, 0x80, 0x00, 0x00, 0x20, 0x78, 0x18, 0x00, 0x00, 0x0C, 0x0F,
  0x03, 0x00, 0x00, 0x01, 0x81, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x3C, 0x06,
  0x00, 0x00, 0x0C, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xF0, 0x0C, 0x00,
  0x00, 0x60, 0x1E, 0x01, 0x80, 0x00, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x78, 0x03, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x20, 0x00, 0x18, 0x01,
  0xE0, 0x06, 0x00, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60, 0x02,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x18, 0x00,
  0x3C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x10, 0x00, 0x1E, 0x00, 0x03, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0xFC, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xE0, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF7, 0xFE, 0x01, 0xE0,
  0x00, 0x7C, 0x1C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x05, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x0C, 0x0F,
  0x80, 0x03, 0x0F, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0D,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x0B, 0x60, 0x00, 0x06, 0xCC, 0x00, 0x03, 0x33,
  0x80, 0x03, 0x84, 0x7C, 0x07, 0xC1, 0x07, 0xFF, 0xC0, 0x40, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xE0,
  0x00, 0xC0, 0x7F, 0xF8, 0x03, 0x07, 0x80, 0x78, 0x0C, 0x38, 0x00, 0x70,
  0x31, 0x80, 0x00, 0x60, 0xCC, 0x00, 0x00, 0xC3, 0x60, 0x00, 0x01, 0x8D,
  0x80, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xF0, 0x00,
  0x00, 0x33, 0xC0, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x0C, 0x36, 0x00, 0x00,
  0x70, 0xCC, 0x00, 0x03, 0x83, 0x1C, 0x00, 0x1C, 0x0C, 0x3C, 0x03, 0xC0,
  0x30, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x04, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x7F, 0xF8, 0x0C, 0x07, 0xC0, 0x78, 0x30, 0x38, 0x00, 0x30, 0xC1,
  0xC0, 0x00, 0x63, 0x0C, 0x00, 0x00, 0xCC, 0x60, 0x00, 0x01, 0xB1, 0x80,
  0x00, 0x06, 0xCC, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x00, 0xB1, 0x80, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x33,
  0x0E, 0x00, 0x01, 0x8C, 0x1C, 0x00, 0x0C, 0x30, 0x3E, 0x01, 0xE0, 0xC0,
  0x3F, 0xFE, 0x03, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0x00, 0x40, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x03, 0xFF, 0xE0, 0x40, 0x7C, 0x07, 0xC2, 0x07,
  0x00, 0x07, 0x10, 0x60, 0x00, 0x1C, 0x86, 0x00, 0x00, 0x64, 0x60, 0x00,
  0x01, 0xA3, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xA3, 0x00, 0x00, 0x0D, 0x1C, 0x00, 0x00, 0xC8,
  0x70, 0x00, 0x0C, 0x41, 0xC0, 0x01, 0xC2, 0x03, 0xC0, 0x3C, 0x10, 0x0F,
  0xFF, 0x80, 0x80, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0E, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x7F, 0xF8, 0x18, 0x3C,
  0x07, 0xC3, 0x1C, 0x00, 0x1C, 0x67, 0x00, 0x01, 0xCC, 0xC0, 0x00, 0x19,
  0xB0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x6F, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x60,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x8C, 0xF8, 0xFE, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x61, 0xB0, 0x00, 0x31, 0x8C,
  0x00, 0x19, 0x83, 0x00, 0x0D, 0x81, 0xC0, 0x07, 0x80, 0x60, 0x03, 0xC0,
  0x18, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x38, 0x03, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0C, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x31, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0xCC, 0x00, 0x0C, 0x30, 0x00,
  0x33, 0x60, 0x00, 0x39, 0x80, 0x00, 0x6F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xBC, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x07, 0x00, 0x18, 0x0F, 0xFF, 0x03,
  0x07, 0x80, 0xF8, 0x61, 0x80, 0x03, 0x8C, 0xE0, 0x00, 0x39, 0x98, 0x00,
  0x03, 0x36, 0x00, 0x00, 0x37, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x01, 0xFF, 0xE0, 0x0C, 0x1F, 0x01,
  0xE0, 0x30, 0xE0, 0x01, 0xE0, 0xC6, 0x00, 0x01, 0xC3, 0x30, 0x00, 0x03,
  0x0D, 0x80, 0x00, 0x06, 0x36, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x06, 0x36, 0x00,
  0x00, 0x38, 0xCC, 0x00, 0x00, 0xC3, 0x38, 0x00, 0x06, 0x0C, 0x70, 0x00,
  0x70, 0x30, 0x78, 0x0F, 0x80, 0xC0, 0xFF, 0xF8, 0x03, 0x00, 0x3F, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x40, 0x7C, 0x07, 0x82, 0x07, 0x00, 0x0E, 0x10,
  0x60, 0x00, 0x18, 0x86, 0x00, 0x00, 0x64, 0x60, 0x00, 0x01, 0xA6, 0x00,
  0x00, 0x0D, 0x30, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x14, 0xC0, 0x00,
  0x01, 0xA7, 0x00, 0x00, 0x19, 0x18, 0x00, 0x00, 0xC8, 0x60, 0x00, 0x1C,
  0x41, 0xC0, 0x01, 0xC2, 0x07, 0x80, 0x3C, 0x10, 0x0F, 0xFF, 0x80, 0x80,
  0x0F, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0xC0, 0xFF,
  0xF0, 0xF0, 0x3C, 0x70, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xE0, 0x0F, 0xC3, 0x80, 0x00, 0x63, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x38, 0x00, 0x07, 0x1F, 0x80, 0x0F, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x30, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x02, 0xD8, 0x00, 0x00, 0xDB, 0x00, 0x00, 0x33, 0x30, 0x00, 0x0C, 0x63,
  0x80, 0x03, 0x0C, 0x3C, 0x03, 0xC1, 0x81, 0xFF, 0xE0, 0x30, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00,
  0x05, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80,
  0xC0, 0x02, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x40,
  0x06, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00,
  0xC0, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40,
  0x60, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00,
  0x00, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x21, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x05, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xE8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 3, 50, 15, 6, -49 },
  { 20, 12, 18, 22, 5, -49 },
  { 47, 40, 49, 44, 2, -49 },
  { 292, 28, 56, 39, 4, -52 },
  { 488, 46, 50, 54, 4, -49 },
  { 776, 41, 50, 48, 4, -49 },
  { 1033, 2, 18, 12, 5, -49 },
  { 1038, 12, 60, 17, 3, -49 },
  { 1128, 13, 60, 17, 2, -49 },
  { 1226, 29, 28, 37, 4, -52 },
  { 1328, 31, 32, 39, 4, -40 },
  { 1452, 6, 17, 12, 3, -8 },
  { 1465, 16, 1, 22, 3, -19 },
  { 1467, 3, 5, 15, 6, -4 },
  { 1469, 20, 49, 22, 1, -49 },
  { 1592, 30, 50, 39, 4, -49 },
  { 1780, 15, 49, 39, 7, -49 },
  { 1872, 29, 49, 39, 4, -49 },
  { 2050, 30, 50, 39, 3, -49 },
  { 2238, 36, 49, 39, 2, -49 },
  { 2459, 29, 50, 39, 5, -49 },
  { 2641, 30, 50, 39, 5, -49 },
  { 2829, 31, 49, 39, 4, -49 },
  { 3019, 30, 50, 39, 4, -49 },
  { 3207, 30, 50, 39, 4, -49 },
  { 3395, 3, 37, 15, 6, -36 },
  { 3409, 6, 45, 15, 3, -36 },
  { 3443, 31, 31, 39, 4, -40 },
  { 3564, 31, 16, 39, 4, -32 },
  { 3626, 31, 31, 39, 4, -40 },
  { 3747, 22, 50, 28, 3, -49 },
  { 3885, 52, 55, 60, 4, -48 },
  { 4243, 39, 49, 39, 0, -49 },
  { 4482, 31, 49, 42, 7, -49 },
  { 4672, 36, 50, 42, 4, -49 },
  { 4897, 36, 49, 47, 7, -49 },
  { 5118, 26, 49, 37, 7, -49 },
  { 5278, 26, 49, 33, 7, -49 },
  { 5438, 39, 50, 49, 4, -49 },
  { 5682, 34, 49, 48, 7, -49 },
  { 5891, 11, 49, 19, 4, -49 },
  { 5959, 16, 61, 16, -7, -49 },
  { 6081, 31, 49, 38, 7, -49 },
  { 6271, 26, 49, 34, 7, -49 },
  { 6431, 43, 49, 57, 7, -49 },
  { 6695, 33, 49, 47, 7, -49 },
  { 6898, 43, 50, 51, 4, -49 },
  { 7167, 28, 49, 39, 7, -49 },
  { 7339, 43, 61, 51, 4, -49 },
  { 7667, 30, 49, 39, 7, -49 },
  { 7851, 29, 50, 37, 4, -49 },
  { 8033, 34, 49, 34, 0, -49 },
  { 8242, 36, 50, 48, 6, -49 },
  { 8467, 38, 49, 38, 0, -49 },
  { 8700, 55, 49, 59, 2, -49 },
  { 9037, 35, 49, 35, 0, -49 },
  { 9252, 34, 49, 34, 0, -49 },
  { 9461, 35, 49, 39, 2, -49 },
  { 9676, 14, 60, 21, 6, -49 },
  { 9781, 20, 49, 22, 1, -49 },
  { 9904, 13, 60, 21, 2, -49 },
  { 10002, 33, 30, 39, 3, -49 },
  { 10126, 27, 2, 27, 0, 6 },
  { 10133, 11, 11, 17, 3, -52 },
  { 10149, 26, 38, 35, 3, -37 },
  { 10273, 30, 53, 40, 6, -52 },
  { 10472, 26, 38, 32, 4, -37 },
  { 10596, 30, 53, 40, 4, -52 },
  { 10795, 29, 38, 37, 4, -37 },
  { 10933, 22, 52, 19, 1, -52 },
  { 11076, 29, 53, 40, 4, -37 },
  { 11269, 27, 52, 39, 6, -52 },
  { 11445, 4, 49, 14, 5, -49 },
  { 11470, 12, 65, 14, -3, -49 },
  { 11568, 25, 52, 31, 6, -52 },
  { 11731, 2, 52, 14, 6, -52 },
  { 11744, 46, 37, 58, 6, -37 },
  { 11957, 27, 37, 39, 6, -37 },
  { 12082, 31, 38, 39, 4, -37 },
  { 12230, 30, 53, 40, 6, -37 },
  { 12429, 29, 53, 40, 4, -37 },
  { 12622, 18, 36, 26, 6, -36 },
  { 12703, 25, 38, 31, 3, -37 },
  { 12822, 19, 46, 22, 1, -45 },
  { 12932, 27, 37, 39, 6, -36 },
  { 13057, 29, 36, 29, 0, -36 },
  { 13188, 44, 36, 47, 1, -36 },
  { 13386, 29, 36, 33, 2, -36 },
  { 13517, 29, 53, 29, 0, -36 },
  { 13710, 25, 36, 31, 3, -36 },
  { 13823, 18, 60, 23, 2, -49 },
  { 13958, 2, 69, 36, 17, -52 },
  { 13976, 19, 60, 23, 2, -49 },
  { 14119, 31, 6, 39, 4, -27 },
};

const GFXfont NotoSans_Thin68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin68pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_THIN68PT7B_H_
