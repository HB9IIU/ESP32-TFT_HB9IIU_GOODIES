#ifndef HB9IIU_SYSTEMINFORMATION_H
#define HB9IIU_SYSTEMINFORMATION_H

void HB9IIUPrintSystemInformation();

#endif // HB9IIU_SYSTEMINFORMATION_H
